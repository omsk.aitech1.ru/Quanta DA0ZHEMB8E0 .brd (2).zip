# Allegro board Quanta ZHE.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
R0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
R0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
R0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
R1206
  rect 1.219x1.626 smd: 1(1.4,0) 2(-1.4,0)
RC3216
  rect 3.2x0.94 smd: 1(0,0.825) 2(0,-0.825)
RC3720-SMT
  rect 3.759x1.016 smd: 1(0,1.008) 2(0,-1.008)
RJ45-C100KU-10809-L-8P
  round 1.295 hole 0.889: 1(3.57,2.3) 2(2.55,3.4) 3(1.53,2.3) 4(0.51,3.4) 5(-0.51,2.3) 6(-1.53,3.4) 7(-2.55,2.3) 8(-3.57,3.4)
  oval 1.626x2.616 hole 0.61x1.6: 9(8.4,0) 10(-8.4,0) 11(8.4,-7.8) 12(-8.4,-7.8)
S0402
  custom 0.125x0.125 smd: 1(0.39,0) 2(-0.39,0)
S0603
  rect 1.041x0.813 smd: 1(0.6,0) 2(-0.6,0)
S0805
  rect 1.346x1.372 smd: 1(0.88,0) 2(-0.88,0)
SC70-2_1-65-6P
  rect 1.27x0.279 smd: 1(1.02,-0.65) 2(1.02,0) 3(1.02,0.65) 4(-1.02,0.65) 5(-1.02,0) 6(-1.02,-0.65)
SC70-2_1-65-6P-G2129TL1U
  rect 1.27x0.305 smd: 1(1.02,-0.65) 2(1.02,0) 3(1.02,0.65) 4(-1.02,0.65) 5(-1.02,0) 6(-1.02,-0.65)
SDCARD-156-2001902600-11P-SMT
  round 1.194 hole 1.194 unplated: (-11.95,0)
  round 0.787 hole 0.787 unplated: (11.9,0)
  rect 0.787x1.803 smd: 1(-10.875,1.46) 2(-9.375,1.46) 3(-6.875,1.46) 4(-4.375,1.46) 5(-1.875,1.46) 6(0.625,1.46) 7(3.125,1.46) 8(5.625,1.46) 9(7.545,1.46) 10(9.245,1.46) 11(10.945,1.46)
  oval 0.94x2.134 hole 0.61x1.168: 12(12.175,-11.2) 13(-12.175,-11.2)
  oval 1.092x2.134 hole 0.61x1.168: 14(12.35,-2.9) 15(-12.35,-2.9)
SHORT3720
  rect 3.759x1.537 smd: 1(0,1.008) 2(0,-1.008)
SOIC8-6-1_27
  rect 0.533x1.753 smd: 1(-1.905,-2.73) 2(-0.635,-2.73) 3(0.635,-2.73) 4(1.905,-2.73) 5(1.905,2.73) 6(0.635,2.73) 7(-0.635,2.73) 8(-1.905,2.73)
SOIC8-7_9-1_27-2_16H
  rect 0.533x1.549 smd: 1(-1.905,-3.775) 2(-0.635,-3.775) 3(0.635,-3.775) 4(1.905,-3.775) 5(1.905,3.775) 6(0.635,3.775) 7(-0.635,3.775) 8(-1.905,3.775)
SON14-3X2-4-15P-SMT
  custom 0.05x0.05 smd: 1(-1.2,-1.076) 2(-0.8,-1.076) 3(-0.4,-1.076) 4(0,-1.076) 5(0.4,-1.076) 6(0.8,-1.076) 7(1.2,-1.076) 8(1.2,1.076) 9(0.8,1.076) 10(0.4,1.076) 11(0,1.076) 12(-0.4,1.076) 13(-0.8,1.076) 14(-1.2,1.076)
  rect 2.489x0.889 smd: 15(0,0)
SOP8-6-1_27-9P-G5795F11U
  rect 0.406x1.981 smd: 1(-1.905,-3.15) 2(-0.635,-3.15) 3(0.635,-3.15) 4(1.905,-3.15) 5(1.905,3.15) 6(0.635,3.15) 7(-0.635,3.15) 8(-1.905,3.15)
  rect 3.607x2.438 smd: 9(0,0)
SOP8-6-1_27-G5461
  rect 0.66x1.6 smd: 1(-1.905,-3) 2(-0.635,-3) 3(0.635,-3) 4(1.905,-3) 5(1.905,3) 6(0.635,3) 7(-0.635,3) 8(-1.905,3)
SOT23-5
  rect 1.016x0.711 smd: 1(1.2,-0.95) 2(1.2,0) 3(1.2,0.95) 4(-1.2,0.95) 5(-1.2,-0.95)
SOT23-5-2_8-95-5P-G708
  rect 1.194x0.533 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,-0.95)
SOT23-6-2_8-95-6P
  rect 1.194x0.508 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,0) 6(-1.5,-0.95)
SOT23-6-2_8-95-6P-G5126TB1U
  rect 1.194x0.508 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,0) 6(-1.5,-0.95)
SOT23_213-3_3-2
  rect 1.27x1.016 smd: 1(1.016,1.016) 2(1.016,-1.016) 3(-1.016,0)
SOT353-1-2_125-65-5P
  rect 1.245x0.279 smd: 1(1.045,-0.65) 2(1.045,0) 3(1.045,0.65) 4(-1.045,0.65) 5(-1.045,-0.65)
SOT363-2_1-65-6P
  rect 0.889x0.356 smd: 1(0.8,-0.65) 2(0.8,0) 3(0.8,0.65) 4(-0.8,0.65) 5(-0.8,0) 6(-0.8,-0.65)
SOT363-2_1-65-6P-PJ4N3KDW
  rect 0.508x0.457 smd: 1(0.95,-0.65) 2(0.95,0) 3(0.95,0.65) 4(-0.95,0.65) 5(-0.95,0) 6(-0.95,-0.65)
SPAD-C354NP
  round 8.992 smd: 1(0,0)
SPAD-RE79X315NP
  rect 2.007x8.001 smd: 1(0,0)
SPAD-RE158X158NP
  rect 4.013x4.013 smd: 1(0,0)
SPAD-RE178X118NP
  rect 4.521x2.997 smd: 1(0,0)
SPAD-RE197X185NP
  rect 5.004x4.699 smd: 1(0,0)
SPAD-RE197X197NP
  rect 5.004x5.004 smd: 1(0,0)
SPAD-RE315X315NP
  rect 8.001x8.001 smd: 1(0,0)
SPAD-ZHP-1P-NP
  custom 2.5x2.5 smd: 1(0,0)
SPAD-ZHP-2P-NP
  custom 0.912x0.912 smd: 1(0,0)
SPAD-ZHP-3P-NP
  custom 1.125x1.125 smd: 1(0,0)
SW-DS-A40E-4P-SMT
  round 1.219 hole 1.219 unplated: (0,-1.5)
  oval 1.016x1.092 hole 1.016x1.092 unplated: (0,1)
  rect 0.787x1.194 smd: 1(-2.15,-1.2) 2(-2.15,1.2) 3(2.15,-1.2) 4(2.15,1.2)
SW-TME-532-V-6P
  rect 1.803x1.092 smd: 1(-3.1,1.85) 2(3.1,1.85) 3(-3.1,-1.85) 4(3.1,-1.85)
  rect 0.991x0.61 smd: 5(0,2.5) 6(0,-2.5)
SW-TME-533B-Q-TR-6P
  rect 1.803x1.092 smd: 1(-3.1,1.85) 2(3.1,1.85) 3(-3.1,-1.85) 4(3.1,-1.85)
  rect 0.991x0.61 smd: 5(0,2.5) 6(0,-2.5)
TP2050
  round 0.508 smd: 1(0,0)
TP2650
  round 0.66 smd: 1(0,0)
TQFN20-4X4-5-25P
  rect 0.305x0.94 smd: 1(-1,-1.925) 2(-0.5,-1.925) 3(0,-1.925) 4(0.5,-1.925) 5(1,-1.925) 11(1,1.925) 12(0.5,1.925) 13(0,1.925) 14(-0.5,1.925) 15(-1,1.925)
  rect 0.94x0.305 smd: 6(1.925,-1) 7(1.925,-0.5) 8(1.925,0) 9(1.925,0.5) 10(1.925,1) 16(-1.925,1) 17(-1.925,0.5) 18(-1.925,0) 19(-1.925,-0.5) 20(-1.925,-1)
  rect 2.108x2.108 smd: 21(0,0)
  round 0.61 hole 0.305: 22(-0.5,-0.5) 23(0.5,-0.5) 24(0.5,0.5) 25(-0.5,0.5)
TRF-15_1X10-1-25P
  rect 0.61x1.346 smd: 1(-5.5,-4.675) 2(-4.5,-4.675) 3(-3.5,-4.675) 4(-2.5,-4.675) 5(-1.5,-4.675) 6(-0.5,-4.675) 7(0.5,-4.675) 8(1.5,-4.675) 9(2.5,-4.675) 10(3.5,-4.675) 11(4.5,-4.675) 12(5.5,-4.675) 13(5.5,4.675) 14(4.5,4.675) 15(3.5,4.675) 16(2.5,4.675) 17(1.5,4.675) 18(0.5,4.675) 19(-0.5,4.675) 20(-1.5,4.675) 21(-2.5,4.675) 22(-3.5,4.675) 23(-4.5,4.675) 24(-5.5,4.675)
  rect 0.787x0.787 smd: 25(-6.75,0)
TSOT23-2_8-95-5P-G916-475TOUF
  rect 1.194x0.533 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,-0.95)
UB3-TARA8-9V1394-9P-SMT
  round 1.295 hole 0.813: 1(3.5,9.73) 2(1,9.73) 3(-1,9.73) 4(-3.5,9.73) 5(-4,8.23) 6(-2,8.23) 7(0,8.23) 8(2,8.23) 9(4,8.23)
  oval 1.397x2.997 hole 0.787x2.388: 10(8,5.65) 11(-8,5.65)
  oval 1.397x2.794 hole 0.787x2.21: 12(-8,0) 13(8,0)
UDFN10-2_5X1-5
  rect 0.254x0.508 smd: 1(-1,-0.4) 2(-0.5,-0.4) 4(0.5,-0.4) 5(1,-0.4) 6(1,0.4) 7(0.5,0.4) 9(-0.5,0.4) 10(-1,0.4)
  rect 0.457x0.508 smd: 3(0,-0.4) 8(0,0.4)
UMT_213-3-1_3
  rect 1.016x0.762 smd: 1(0.991,0.66) 2(0.991,-0.66) 3(-0.991,0)
unnamed#2
  round 1.016 smd: 1(0,0)
USB-10355-30002-9P
  round 1.194 hole 0.787: 1(3.5,9.23) 2(1,9.23) 3(-1,9.23) 4(-3.5,9.23) 5(-4,7.73) 6(-2,7.73) 7(0,7.73) 8(2,7.73) 9(4,7.73)
  oval 1.803x2.819 hole 0.787x1.803: 10(7.85,6.8) 11(-7.85,6.8)
  oval 1.803x2.921 hole 0.787x1.905: 12(-7.85,0) 13(7.85,0)
USB-020173MR004S55PZR-4P-R-V
  round 1.397 hole 0.991: 1(3.5,5.875) 2(1,5.875) 3(-1,5.875) 4(-3.5,5.875)
  oval 1.524x2.616 hole 0.508x1.6: 5(7.75,2.525) 6(-7.75,2.525)
  rect 1.702x2.591 hole 0.61x2.311: 7(7.75,-2.525) 8(-7.75,-2.525)
WQFN20-3X3-4-21P
  rect 0.203x0.991 smd: 1(-0.8,-1.6) 2(-0.4,-1.6) 3(0,-1.6) 4(0.4,-1.6) 5(0.8,-1.6) 11(0.8,1.6) 12(0.4,1.6) 13(0,1.6) 14(-0.4,1.6) 15(-0.8,1.6)
  rect 0.991x0.203 smd: 6(1.6,-0.8) 7(1.6,-0.4) 8(1.6,0) 9(1.6,0.4) 10(1.6,0.8) 16(-1.6,0.8) 17(-1.6,0.4) 18(-1.6,0) 19(-1.6,-0.4) 20(-1.6,-0.8)
  rect 1.702x1.702 smd: 21(0,0)
XTL-2_05X1_65-1_4X1_1-0_6H
  rect 0.889x0.787 smd: 1(-0.7,-0.55) 2(0.7,-0.55) 3(0.7,0.55) 4(-0.7,0.55)
XTL-3_2X1_5-2_5-0_8H
  rect 0.991x1.803 smd: 1(-1.25,0) 2(1.25,0)
XTL-3_2X2_5-2_2X1_7-0_8H
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)

## Nets
1.8V_LDO: C223.2 R232.1 U12.5(VOUT)
3V_LDO: R254.1 R266.1
5V_HSMBCK: D35.1(CATHODE) R390.1
5V_HSMBDT: D36.1(CATHODE) R395.1
+1.2V: C342.2 C343.2 C344.2 C345.1 C346.2 C348.2 C349.2 C354.2 C355.2 C363.2 C364.2 C365.2 PQ2.1(S) PR70.1 U6.6(VDD12#1) U6.11(VDDA12) U6.15(VDDTX12#2) U6.18(VDDTX12#1) U6.30(VDD12#2) U6.43(VDDRX12#1) U6.46(VDDRX12#2)
+1.2VSUS: C127.1 C128.2 C129.2 C130.2 C157.1 C189.2 C192.1 C199.1 C200.1 C209.1 C210.1 C230.2 C232.1 C235.1 C240.1 C241.1 C242.1 C249.1 C250.1 C251.1 C252.1 C253.1 C254.1 C255.1 C256.1 C259.1 C274.1 C276.1 C277.1 C279.1 C281.1 C282.1 C285.1 C399.2 C400.2 C401.1 C402.2 C409.1 C427.1 C431.1 C433.1 C435.1 C436.1 C439.2 C440.1 C441.1 D12.1 D13.1 D19.1 D20.1 D23.1 D25.1 JDIM1.12(DM0) JDIM1.33(DM1) JDIM1.54(DM2) JDIM1.75(DM3) JDIM1.96(DBI8#) JDIM1.111(VDD1) JDIM1.112(VDD2) JDIM1.117(VDD3) JDIM1.118(VDD4) JDIM1.123(VDD5) JDIM1.124(VDD6) JDIM1.129(VDD7) JDIM1.130(VDD8) JDIM1.135(VDD9) JDIM1.136(VDD10) JDIM1.141(VDD11) JDIM1.142(VDD12) JDIM1.147(VDD13) JDIM1.148(VDD14) JDIM1.153(VDD15) JDIM1.154(VDD16) JDIM1.159(VDD17) JDIM1.160(VDD18) JDIM1.163(VDD19) JDIM1.178(DM4) JDIM1.199(DM5) JDIM1.220(DM6) JDIM1.241(DM7) PC224.1 PJ14.1 PQ2.3(D) PU15.19(VLDOIN) R181.1 R189.1 R279.2 R280.2 R303.1 R304.1 R305.1 R306.1 R307.1 R308.1 R326.1 R327.1 R328.1 R329.1 R330.1 R332.1 R512.1 R536.2 R589.1 R625.1 U9.A1(VDDQ#A1) U9.A9(VDDQ#A9) U9.B3(VDD#B3) U9.B9(VDD#B9) U9.C1(VDDQ#C1) U9.D1(VDD#D1) U9.D9(VDDQ#D9) U9.E2(DMU_N/DBIU_N) U9.E7(DML_N/DBIL_N) U9.F2(VDDQ#F2) U9.F8(VDDQ#F8) U9.G1(VDDQ#G1) U9.G7(VDD#G7) U9.G9(VDDQ#G9) U9.J1(VDD#J1) U9.J2(VDDQ#J2) U9.J8(VDDQ#J8) U9.J9(VDD#J9) U9.L1(VDD#L1) U9.L9(VDD#L9) U9.R1(VDD#R1) U9.T9(VDD#T9) U13.A1(VDDQ#A1) U13.A9(VDDQ#A9) U13.B3(VDD#B3) U13.B9(VDD#B9) U13.C1(VDDQ#C1) U13.D1(VDD#D1) U13.D9(VDDQ#D9) U13.E2(DMU_N/DBIU_N) U13.E7(DML_N/DBIL_N) U13.F2(VDDQ#F2) U13.F8(VDDQ#F8) U13.G1(VDDQ#G1) U13.G7(VDD#G7) U13.G9(VDDQ#G9) U13.J1(VDD#J1) U13.J2(VDDQ#J2) U13.J8(VDDQ#J8) U13.J9(VDD#J9) U13.L1(VDD#L1) U13.L9(VDD#L9) U13.R1(VDD#R1) U13.T9(VDD#T9) U25.A1(VDDQ#A1) U25.A9(VDDQ#A9) U25.B3(VDD#B3) U25.B9(VDD#B9) U25.C1(VDDQ#C1) U25.D1(VDD#D1) U25.D9(VDDQ#D9) U25.E2(DMU_N/DBIU_N) U25.E7(DML_N/DBIL_N) U25.F2(VDDQ#F2) U25.F8(VDDQ#F8) U25.G1(VDDQ#G1) U25.G7(VDD#G7) U25.G9(VDDQ#G9) U25.J1(VDD#J1) U25.J2(VDDQ#J2) U25.J8(VDDQ#J8) U25.J9(VDD#J9) U25.L1(VDD#L1) U25.L9(VDD#L9) U25.R1(VDD#R1) U25.T9(VDD#T9) U30.A1(VDDQ#A1) U30.A9(VDDQ#A9) U30.B3(VDD#B3) U30.B9(VDD#B9) U30.C1(VDDQ#C1) U30.D1(VDD#D1) U30.D9(VDDQ#D9) U30.E2(DMU_N/DBIU_N) U30.E7(DML_N/DBIL_N) U30.F2(VDDQ#F2) U30.F8(VDDQ#F8) U30.G1(VDDQ#G1) U30.G7(VDD#G7) U30.G9(VDDQ#G9) U30.J1(VDD#J1) U30.J2(VDDQ#J2) U30.J8(VDDQ#J8) U30.J9(VDD#J9) U30.L1(VDD#L1) U30.L9(VDD#L9) U30.R1(VDD#R1) U30.T9(VDD#T9)
+1.05V: C115.2 PC32.1 PC165.1 PJ6.2 PR18.1 PR23.1 PR26.1 PR181.1 PR187.1 PR192.1 R128.2 R134.2 R158.2 R179.2 R455.2 R456.2 R457.1 R468.1 R470.1
+1.5V: C283.2 L9.1 PR225.2 Q13.2(G) R366.2
+1.5VA: C269.1 C272.1 L9.2 U16.40(AVDD2)
+1.8V: PQ19.1(S) PR1.1 R7.1 R56.2 R57.1 R197.1 R198.1 R202.1 R409.2
+1.8V_EMMC: C163.1 C164.1 C173.2 C184.2 C186.2 R202.2 U26.C6(VCCQ#1) U26.M4(VCCQ#2) U26.N4(VCCQ#3) U26.P3(VCCQ#4) U26.P5(VCCQ#5)
+1.8V_S5: C317.1 C350.1 PJ9.2 PQ19.3(D) PR108.1 PR202.1 Q11.2(G) Q12.2(G) Q20.2(G) Q20.5(G) R6.1 R37.2 R46.2 R51.2 R61.2 R65.2 R72.2 R75.2 R100.1 R104.1 R106.1 R108.1 R109.1 R111.1 R112.1 R117.2 R130.2 R136.2 R137.2 R140.2 R141.2 R149.2 R152.2 R156.2 R157.2 R164.2 R166.2 R169.1 R176.2 R185.2 R186.2 R199.2 R257.1 R269.2 R270.2 R281.1 R360.2 R400.2 R402.2 R403.2 R407.2 R408.2 R416.2 R417.2 R418.2 R434.1 R444.2 R447.2 R475.2 R476.2 R482.2 R483.1 R485.1 R487.2 R489.2 R491.2 R492.2 R495.2 R496.1 R501.2 R503.2 R506.2 R509.2 R510.2 R511.2 R514.2 R515.2 R523.2 R525.2 R526.2 R527.2 U10.1(VCCA) U21.8(VCC) U23.1(VCCA)
+1.24V_S5: PJ7.2 R119.1 R123.1 R129.1 R143.1 R153.1 R161.1 R162.1
+2.5V: PQ10.1(S) PR79.1 R301.2
+2.5V_SUS: C131.1 C132.1 C197.2 C198.2 C222.2 C224.2 C238.1 C239.1 C260.1 C262.1 C397.1 C398.1 C413.2 C414.1 C430.1 C432.1 C442.1 JDIM1.257(VPP1) JDIM1.259(VPP2) PJ4.1 PQ10.3(D) U9.B1(VPP#B1) U9.R9(VPP#R9) U13.B1(VPP#B1) U13.R9(VPP#R9) U25.B1(VPP#B1) U25.R9(VPP#R9) U30.B1(VPP#B1) U30.R9(VPP#R9)
+3V: C58.1 C74.1 C76.2 C156.1 C273.1 C275.1 C542.1 PC178.1 PC180.1 PR9.1 PR59.1 PR114.1 PR151.1 PR175.1 PR185.2 PR218.1 PR244.1 PU9.8(OUT2#1) PU9.9(OUT2#2) Q29.2(G) Q29.5(G) Q32.2(G) Q32.5(G) R26.1 R58.1 R71.1 R81.1 R82.2 R85.2 R86.2 R115.2 R173.1 R221.1 R234.2 R262.2 R277.2 R285.1 R302.2 R310.2 R323.1 R324.1 R333.1 R336.2 R337.1 R341.1 R342.2 R343.2 R349.1 R350.2 R351.2 R362.2 R371.2 R383.2 R392.2 R393.2 R419.1 R454.1 R472.1 R551.1 R582.1 R607.2 R619.2 U7.4(IN#1) U7.5(IN#2) U27.4(+VS) U34.5(VCC)
+3V_EC: C229.1 R285.2 R286.2 U14.11(VCC)
+3V_EMMC: C161.1 C162.2 C168.1 C175.2 C178.2 R173.2 U26.E6(VCC#1) U26.F5(VCC#2) U26.J10(VCC#3) U26.K9(VCC#4)
+3V_HDMI: R27.1 R38.1 R39.1 R42.1 R43.1 R60.1 R78.2 R81.2 U6.1(VDD33#1) U6.24(VDD33#2)
+3V_LDO_EC: D17.1(CATHODE) R247.1 R250.2 R258.2 R259.2 R266.2 R267.2 R268.2 R273.2 R291.2 R311.1
+3V_MINI1_VDD: C445.2 C446.2 C454.1 C457.2 CN10.2(3.3VAUX#1) CN10.4(3.3VAUX#2) CN10.72(3.3VAUX#3) CN10.74(3.3VAUX#4) Q37.2(G) Q38.2(G) R322.2 R573.2 R585.2 R601.1 R607.1 R615.2 R616.1 U33.6(VCCB)
+3V_RTC: D29.3(COMMON ANODE) R52.2 R92.1 R356.2 R357.1 R358.1 R367.1
+3V_RTC_1: D29.1(CATHODE1) R387.2
+3V_S5: C20.2 C103.1 C107.1 C112.1 C139.1 C469.1 PC163.1 PC168.1 PR95.1 PR143.1 PR220.1 PU9.13(VOUT1#1) PU9.14(VOUT1#2) Q36.1(S) R80.1 R174.1 R216.2 R284.1 R286.1 R344.2 R397.2 R398.2 R405.2 R420.1 R433.1 R458.2 R528.1 R602.1 R615.1 R617.2 R623.1 U10.6(VCCB) U22.AG21(VCC_3P3V_A1) U22.AJ21(VCC_3P3V_A2) U22.T18(VCC_3P3V_A3) U22.T20(VCC_3P3V_A4) U22.U17(VCC_3P3V_A5) U22.V18(VCC_3P3V_A6) U22.V20(VCC_3P3V_A7) U22.Y18(VCC_3P3V_A8) U22.Y20(VCC_3P3V_A9) U23.6(VCCB) U33.1(VCCA)
+3VPCU: C75.1 C126.2 C147.2 CN7.1 D29.2(CATHODE2) LED1.1 LED1.2 LED2.1 LED2.2 PC159.1 PC183.1 PJ8.2 PJ10.2 PR87.2 PR89.2 PR97.2 PR178.1 PR205.1 PR231.1 PR258.2 PU9.1(VIN1#1) PU9.2(VIN1#2) PU9.6(VIN2#1) PU9.7(VIN2#2) Q3.1(S) Q14.1(S) R5.2 R8.2 R12.2 R13.2 R89.1 R125.1 R126.2 R273.1 R321.1 R331.2 R368.1 R370.2 R384.1 R432.2 R438.2 RP1.5(R10) RP1.10(R1)
+3VPCU_EC: C226.1 C228.1 C245.1 C271.1 C428.1 C429.1 L4.2 L7.1 R311.2 U14.26(VSTBY_1) U14.50(VSTBY_2) U14.92(VSTBY_3) U14.114(VSTBY_4) U14.121(VSTBY_6)
+3VPCU_ECPLL: C221.1 L4.1 U14.127(VSTBY(PLL))
+5V: C234.1 C246.2 C325.1 C471.2 D35.2(ANODE) D36.2(ANODE) L6.1 L10.1 PC102.1 PC103.1 PR264.1 PU4.8(OUT2#1) PU4.9(OUT2#2) Q25.1(S) R69.1 R339.1 R372.1 R583.2 U15.1(S\H\D\N\) U15.3(IN) U19.3(VIN) U31.2(VIN)
+5V_FAN1: C437.2 C447.2 CN9.1 U31.3(VO)
+5V_HDD1: C314.2 C318.1 C319.2 C487.2 C488.2 CN15.14 CN15.15 CN15.16 CN15.17 R339.2
+5V_KB: C308.1 C315.1 CN13.3 CN13.4 Q25.3(D)
+5V_PVDD: C288.1 C289.1 C295.1 C296.1 L10.2 U16.41(PVDD1) U16.46(PVDD2)
+5V_S5: C12.1 C16.1 C126.1 C170.1 C177.2 C335.1 PC101.1 PC104.1 PR13.1 PR38.1 PR69.1 PR158.1 PR206.2 PR240.2 PR241.1 PU4.13(VOUT1#1) PU4.14(VOUT1#2) R386.1 R389.1 U4.5(IN) U18.5(IN) U24.5(IN)
+5VA: C247.2 C248.1 C264.1 C270.1 L6.2 R294.1 U15.4(OUT) U16.26(AVDD1)
+5VPCU: PC96.1 PC97.1 PJ15.1 PR4.1 PR8.2 PR99.2 PR180.1 PR222.2 PU4.1(VIN1#1) PU4.2(VIN1#2) PU4.6(VIN2#1) PU4.7(VIN2#2)
+12V_PANEL: D3.2(ANODE) PR22.1 R95.2
+A3VPCU: C257.1 L7.2 U14.74(AVCC)
+V3A_LX: PC55.2 PL7.1 PR73.1 PU13.2(LX#1) PU13.3(LX#2)
+V3A_LX_R: PC56.1 PR73.2
+V3A_OUT: PC50.1 PC52.1 PC53.1 PC54.1 PC197.1 PC198.1 PC199.1 PJ10.1 PL7.2 PR209.1
+V3A_VIN: PC206.2 PC207.1 PC208.1 PC209.2 PJ12.1 PU13.5(VIN)
+V5P5A_LX: PC67.2 PL8.1 PR81.1 PU14.2(LX#1) PU14.3(LX#2)
+V5P5A_LX_R: PC63.1 PR81.2
+V5P5A_OUT: PC73.1 PC75.1 PC79.1 PC84.1 PC230.1 PC231.1 PC236.1 PJ15.2 PL8.2 PR255.1
+V5P5A_VIN: PC58.1 PC59.2 PC61.2 PC210.1 PC213.1 PJ11.1 PU14.5(VIN)
+VCC_V3A: PC203.1 PU13.9(VCC)
+VCC_V5P5A: PC219.1 PU14.11(VCC)
+VCC_VCCGI: C27.1 C28.1 C29.1 C30.2 C31.1 C32.1 C33.1 C38.2 C41.2 C44.2 C45.2 C46.2 C47.2 C48.2 C49.1 C53.2 C63.2 C65.2 C68.2 C77.2 C79.2 C80.1 C83.2 C86.1 C88.1 C90.1 C93.2 C94.2 C95.1 C102.1 C110.2 C111.2 C121.2 C133.1 C356.2 C357.2 C358.2 C359.1 C360.1 C370.2 C371.2 C372.2 C373.2 C374.2 PC3.1 PC4.1 PC5.1 PC6.1 PC7.2 PC12.1 PC13.1 PC14.1 PC15.1 PC112.1 PC113.1 PC114.1 PC115.1 PC116.1 PC117.1 PC129.1 PC130.1 PC131.1 PC132.1 PC133.2 PL2.2 PR3.2 PR135.1 U22.AA28(VCC_VCG1) U22.AA29(VCC_VCG2) U22.AA31(VCC_VCG3) U22.AA33(VCC_VCG4) U22.AC28(VCC_VCG5) U22.AC31(VCC_VCG6) U22.AE28(VCC_VCG7) U22.AE29(VCC_VCG8) U22.AE31(VCC_VCG9) U22.AF31(VCC_VCG10) U22.AF33(VCC_VCG11) U22.AG31(VCC_VCG12) U22.AG33(VCC_VCG13) U22.AJ31(VCC_VCG14) U22.AJ33(VCC_VCG15) U22.AJ35(VCC_VCG16) U22.AL31(VCC_VCG17) U22.AL33(VCC_VCG18) U22.AL35(VCC_VCG19) U22.AM33(VCC_VCG20) U22.AM35(VCC_VCG21) U22.AM36(VCC_VCG22) U22.D31(VCC_VCG23) U22.D33(VCC_VCG24) U22.D37(VCC_VCG25) U22.D39(VCC_VCG26) U22.P39(VCC_VCG27) U22.P41(VCC_VCG28) U22.T28(VCC_VCG29) U22.T29(VCC_VCG30) U22.T31(VCC_VCG31) U22.T33(VCC_VCG32) U22.T35(VCC_VCG33) U22.T36(VCC_VCG34) U22.V28(VCC_VCG35) U22.V29(VCC_VCG36) U22.V31(VCC_VCG37) U22.V33(VCC_VCG38) U22.V35(VCC_VCG39) U22.V36(VCC_VCG40) U22.Y28(VCC_VCG41) U22.Y29(VCC_VCG42) U22.Y33(VCC_VCG43) U22.Y35(VCC_VCG44)
+VCCDDQ: C148.1 C155.2 C167.2 C169.2 C191.2 C205.2 C206.1 C207.2 C212.2 C216.2 R279.1 R280.1 U22.AP18(VDDQ1) U22.AP21(VDDQ2) U22.AP36(VDDQ3) U22.AP38(VDDQ4) U22.AT18(VDDQ5) U22.AT20(VDDQ6) U22.AT21(VDDQ7) U22.AT35(VDDQ8) U22.AT36(VDDQ9) U22.AT38(VDDQ10) U22.BA13(VDDQ11) U22.BA15(VDDQ12) U22.BA25(VDDQ13) U22.BA31(VDDQ14) U22.BA41(VDDQ15) U22.BA43(VDDQ16)
+VCCIOA: C141.2 C145.1 C146.1 C149.1 C150.2 C176.2 R179.1 U22.AP25(VCCIOA1) U22.AP31(VCCIOA2) U22.AT25(VCCIOA3) U22.AT27(VCCIOA4) U22.AT28(VCCIOA5) U22.AT29(VCCIOA6) U22.AT31(VCCIOA7)
+VCCRAM_1P05: C59.1 C66.1 C73.1 C99.2 C100.2 C101.1 C108.1 C113.1 C120.2 R455.1 R456.1 U22.AA36(VCCRAM_1P051) U22.AA38(VCCRAM_1P052) U22.AC33(VCCRAM_1P053) U22.AC35(VCCRAM_1P054) U22.AC36(VCCRAM_1P055) U22.AC38(VCCRAM_1P056) U22.AE33(VCCRAM_1P057) U22.AE35(VCCRAM_1P058) U22.AE36(VCCRAM_1P059) U22.AE38(VCCRAM_1P0510) U22.AF27(VCCRAM_1P0511) U22.AF28(VCCRAM_1P0512) U22.AF36(VCCRAM_1P0513) U22.AF38(VCCRAM_1P0514) U22.Y36(VCCRAM_1P0515) U22.Y38(VCCRAM_1P0516)
+VCCRAM_1P05_FHV0: R134.1 U22.AG51(VCC_1P05_INT2)
+VCCRAM_1P05_FHV1: R128.1 U22.AG49(VCC_1P05_INT1)
+VCCRAM_1P05_FUSE: R158.1 U22.AJ51(VCC_1P05_INT3)
+VDD1_1P8: C67.2 C81.1 C87.1 C91.1 C96.1 C109.1 R61.1 U22.AG23(VCC_1P8V_A1) U22.AJ23(VCC_1P8V_A2) U22.T21(VCC_1P8V_A3) U22.T23(VCC_1P8V_A4) U22.T25(VCC_1P8V_A5) U22.V21(VCC_1P8V_A6) U22.V23(VCC_1P8V_A7) U22.V25(VCC_1P8V_A8)
+VDD2_1P24_AUD_ISH: C117.1 C123.1 R129.2 U22.AC18(VDD2_1P2_AUD1) U22.AC20(VDD2_1P2_AUD2)
+VDD2_1P24_DSI_CSI: C151.1 R162.2 U22.AW12(VDD2_1P2_DSI_CSI)
+VDD2_1P24_GLML: C134.1 C152.2 C166.2 R161.2 U22.AL36(VDD2_1P2_GLM1) U22.AL38(VDD2_1P2_GLM2) U22.AM20(VDD2_1P2_GLM3) U22.AP20(VDD2_1P2_GLM4)
+VDD2_1P24_MPHY: C104.2 C105.2 C106.2 C114.1 C116.1 C118.1 R119.2 U22.AC21(VDD2_1P2_MPHY1) U22.AE20(VDD2_1P2_MPHY2) U22.AE21(VDD2_1P2_MPHY3) U22.AF20(VDD2_1P2_MPHY4) U22.AF21(VDD2_1P2_MPHY5)
+VDD2_1P24_PLL: C137.1 C138.2 C140.1 R153.2 U22.AL18(VDD2_1P2_PLL1) U22.AM18(VDD2_1P2_PLL2)
+VDD2_1P24_USB2: C124.2 C125.1 R143.2 U22.AG18(VDD2_1P2_USB2) U22.AJ20(VDD2_1P2_USB3)
+VDD2_1P24_VNNAON: R123.2 U22.AA18(VDD2_1P2_VNNAON1) U22.AA20(VDD2_1P2_VNNAON2)
+VDDQ: PC225.1 PR253.1 R588.1
+VDDQ_VTT: C193.1 C194.1 C202.1 C204.1 C211.1 C214.1 C215.1 C286.1 C290.1 C291.1 C292.1 C293.1 C415.1 C419.1 C420.1 C424.1 JDIM1.258(VTT) PC227.1 PU15.2(VTTSNS) PU15.20(VTT) R206.1 R208.1 R209.1 R210.1 R211.1 R213.1 R214.1 R217.1 R218.1 R219.1 R220.1 R222.1 R223.1 R224.1 R228.1 R230.1 R231.1 R235.1 R237.1 R238.1 R239.1 R240.1 R241.1 R244.1 R246.1 R252.1 R253.1 R265.1
+VIN: C60.2 C62.1 C177.1 D4.2(ANODE) PC148.1 PC152.1 PC204.1 PC211.1 PC212.1 PC232.1 PC233.1 PJ1.2 PJ2.2 PJ3.1 PJ11.2 PJ12.2 PJ13.1 PQ13.5(D) PQ23.5(D) PR17.1 PR77.1 PR78.1 PR150.2 PR164.2 R94.2
+VIN_BLIGHT: C36.1 C40.2 C52.2 C64.1 CN5.1 CN5.2 D3.1(CATHODE) D4.1(CATHODE) R94.1
+VIN_VCC_VCGI: PC8.1 PC9.1 PC10.1 PC120.2 PC121.2 PJ1.1 PQ14.5(D) PR14.1
+VIN_VNN: PC16.1 PC17.1 PC18.1 PC144.2 PC145.2 PJ2.1 PQ18.5(D) PR168.1
DVDD: C218.1 C219.1 C220.2 R277.1 U11.4(3V3_IN)
DVDD_IO: C302.1 C309.1 R362.1 R366.1 U16.9(DVDD-IO)
GND: C1.2 C2.1 C4.1 C5.1 C6.2 C7.1 C8.2 C9.2 C10.1 C11.1 C12.2 C15.1 C16.2 C18.2 C19.1 C20.1 C21.1 C22.1 C23.2 C24.2 C27.2 C28.2 C29.2 C30.1 C31.2 C32.2 C33.2 C34.1 C35.2 C36.2 C37.2 C38.1 C39.1 C40.1 C41.1 C42.1 C43.1 C44.1 C45.1 C46.1 C47.1 C48.1 C49.2 C50.2 C51.2 C52.1 C53.1 C58.2 C59.2 C60.1 C61.1 C62.2 C63.1 C64.2 C65.1 C66.2 C67.1 C68.1 C73.2 C74.2 C76.1 C77.1 C79.1 C80.2 C81.2 C82.2 C83.1 C84.1 C85.1 C86.2 C87.2 C88.2 C89.2 C90.2 C91.2 C92.2 C93.1 C94.1 C95.2 C96.2 C97.1 C98.1 C99.1 C100.1 C101.2 C102.2 C103.2 C104.1 C105.1 C106.1 C107.2 C108.2 C109.2 C110.1 C111.1 C112.2 C113.2 C114.2 C115.1 C116.2 C117.2 C118.2 C120.1 C121.1 C122.2 C123.2 C124.1 C125.2 C127.2 C128.1 C129.1 C130.1 C131.2 C132.2 C133.2 C134.2 C135.2 C136.2 C137.2 C138.1 C139.2 C140.2 C141.1 C142.2 C143.2 C144.2 C145.2 C146.2 C147.1 C148.2 C149.2 C150.1 C151.2 C152.1 C155.1 C156.2 C157.2 C158.1 C159.1 C160.1 C161.2 C162.1 C163.2 C164.2 C165.1 C166.1 C167.1 C168.2 C169.1 C170.2 C171.1 C172.2 C173.1 C174.1 C175.1 C176.1 C178.1 C179.1 C180.1 C181.1 C182.1 C183.2 C184.1 C186.1 C187.2 C189.1 C191.1 C192.2 C193.2 C194.2 C196.1 C197.1 C198.1 C199.2 C200.2 C201.1 C202.2 C203.1 C204.2 C205.1 C206.2 C207.1 C208.2 C209.2 C210.2 C211.2 C212.1 C214.2 C215.2 C216.1 C217.2 C218.2 C219.2 C220.1 C221.2 C222.1 C223.1 C224.1 C225.1 C226.2 C228.2 C229.2 C230.1 C231.2 C232.2 C233.1 C234.2 C235.2 C236.2 C237.2 C238.2 C239.2 C240.2 C241.2 C242.2 C243.1 C244.2 C245.2 C246.1 C249.2 C250.2 C251.2 C252.2 C253.2 C254.2 C255.2 C256.2 C258.2 C259.2 C260.2 C262.2 C267.2 C268.2 C271.2 C273.2 C274.2 C275.2 C276.2 C277.2 C278.2 C279.2 C280.1 C281.2 C282.2 C283.1 C285.2 C286.2 C288.2 C289.2 C290.2 C291.2 C292.2 C293.2 C294.2 C295.2 C296.2 C297.2 C298.1 C299.1 C300.2 C301.2 C302.2 C304.1 C305.2 C306.2 C308.2 C309.2 C310.1 C311.2 C312.2 C313.2 C314.1 C315.2 C316.1 C317.2 C318.2 C319.1 C320.2 C321.2 C322.2 C323.2 C324.2 C325.2 C326.2 C327.2 C328.2 C329.2 C330.1 C331.1 C332.2 C333.2 C334.2 C335.2 C336.2 C337.1 C338.2 C339.2 C340.2 C341.2 C342.1 C343.1 C344.1 C345.2 C346.1 C347.1 C348.1 C349.1 C350.2 C351.2 C352.2 C353.1 C354.1 C355.1 C356.1 C357.1 C358.1 C359.2 C360.2 C361.1 C362.1 C363.1 C364.1 C365.1 C370.1 C371.1 C372.1 C373.1 C374.1 C375.1 C376.1 C377.1 C388.2 C389.2 C390.1 C391.1 C392.1 C393.1 C394.1 C395.1 C396.1 C397.2 C398.2 C399.1 C400.1 C401.2 C402.1 C403.1 C404.1 C405.1 C406.1 C407.1 C408.1 C409.2 C411.1 C412.2 C413.1 C414.2 C415.2 C416.2 C417.2 C418.2 C419.2 C420.2 C421.2 C422.2 C423.1 C424.2 C425.2 C426.1 C427.2 C428.2 C429.2 C430.2 C431.2 C432.2 C433.2 C434.1 C435.2 C436.2 C437.1 C438.2 C439.1 C440.2 C441.2 C442.2 C443.1 C444.1 C445.1 C446.1 C447.1 C448.2 C449.1 C450.1 C452.2 C454.2 C457.1 C462.1 C463.1 C464.1 C465.1 C466.1 C467.2 C468.2 C469.2 C471.1 C472.2 C473.2 C474.2 C475.1 C476.2 C477.1 C478.1 C479.1 C480.2 C481.2 C482.2 C483.2 C484.2 C485.1 C487.1 C488.1 C542.2 CN1.2(D2_SHIELD) CN1.5(D1_SHIELD) CN1.8(D0_SHIELD) CN1.11(CLK_SHIELD) CN1.17(DDC/CEC_GND) CN1.20 CN1.21 CN1.22 CN1.23 CN2.4(GND) CN2.7(GND_DRAIN) CN2.10(SHIELD#2) CN2.11(SHIELD#1) CN2.12(SHIELD#4) CN2.13(SHIELD#3) CN3.4(GND) CN3.5(SHIELD#2) CN3.6(SHIELD#1) CN3.7(SHIELD#3) CN3.8(SHIELD#4) CN5.17 CN5.20 CN5.23 CN5.26 CN5.29 CN5.32 CN5.35 CN5.41 CN5.42 CN5.43 CN5.44 CN6.4(GND) CN6.7(GND_DRAIN) CN6.10(SHIELD#2) CN6.11(SHIELD#1) CN6.12(SHIELD#4) CN6.13(SHIELD#3) CN7.8 CN7.10 CN7.12 CN7.14 CN7.19 CN7.20 CN9.3 CN9.4 CN9.5 CN9.6 CN10.1(GND#3) CN10.7(GND#4) CN10.18(GND#13) CN10.33(GND#5) CN10.39(GND#6) CN10.45(GND#7) CN10.51(GND#8) CN10.57(GND#9) CN10.63(GND#10) CN10.69(GND#11) CN10.75(GND#12) CN10.76(GND#1) CN10.77(GND#2) CN11.5(VSS#1) CN11.8(VSS#2) CN11.12(GND#2) CN11.14(GND#1) CN12.4 CN12.9 CN12.10 CN13.1 CN13.2 CN13.5 CN13.6 CN14.2 CN15.1 CN15.4 CN15.7 CN15.11 CN15.12 CN15.13 CN15.21 CN15.22 CN15.23 CN15.24 CN16.28 CN16.29 CN16.30 CN17.5 CN17.6 CP1.2(C2) CP1.4(C4) CP1.6(C6) CP1.8(C8) CP2.2(C2) CP2.4(C4) CP2.6(C6) CP2.8(C8) CP3.2(C2) CP3.4(C4) CP3.6(C6) CP3.8(C8) CP4.2(C2) CP4.4(C4) CP4.6(C6) CP4.8(C8) CP5.2(C2) CP5.4(C4) CP5.6(C6) CP5.8(C8) CP6.2(C2) CP6.4(C4) CP6.6(C6) CP6.8(C8) D1.1 D2.1 D7.2 D12.2 D13.2 D15.2 D19.2 D20.2 D23.2 D24.2 D25.2 D28.1 D30.1 D37.1 D38.1 D40.2 D41.2 EC1.1 EC2.1 EC3.1 EC4.1 EC5.1 EC6.2 ESD2.2(GND) HE1.3(GND) HOLE1.1 HOLE1.2 HOLE1.3 HOLE1.4 HOLE1.5 HOLE1.6 HOLE1.7 HOLE1.8 HOLE1.9 HOLE4.1 HOLE5.1 HOLE5.2 HOLE5.3 HOLE5.4 HOLE5.5 HOLE5.6 HOLE5.7 HOLE5.8 HOLE5.9 HOLE6.1 HOLE6.2 HOLE6.3 HOLE6.4 HOLE6.5 HOLE6.6 HOLE6.7 HOLE6.8 HOLE6.9 HOLE8.1 HOLE8.2 HOLE8.3 HOLE8.4 HOLE8.5 HOLE8.6 HOLE8.7 HOLE8.8 HOLE8.9 HOLE9.1 HOLE9.2 HOLE9.3 HOLE9.4 HOLE9.5 HOLE9.6 HOLE9.7 HOLE9.8 HOLE9.9 HOLE10.1 HOLE10.2 HOLE10.3 HOLE10.4 HOLE10.5 HOLE10.6 HOLE10.7 HOLE10.8 HOLE10.9 HOLE12.1 HOLE13.1 HOLE14.1 HOLE15.1 HOLE16.1 HOLE17.1 J1.2 JDIM1.1(VSS1) JDIM1.2(VSS48) JDIM1.5(VSS2) JDIM1.6(VSS49) JDIM1.9(VSS3) JDIM1.10(VSS50) JDIM1.14(VSS51) JDIM1.15(VSS4) JDIM1.18(VSS52) JDIM1.19(VSS5) JDIM1.22(VSS53) JDIM1.23(VSS6) JDIM1.26(VSS54) JDIM1.27(VSS7) JDIM1.30(VSS55) JDIM1.31(VSS8) JDIM1.35(VSS9) JDIM1.36(VSS56) JDIM1.39(VSS10) JDIM1.40(VSS57) JDIM1.43(VSS11) JDIM1.44(VSS58) JDIM1.47(VSS12) JDIM1.48(VSS59) JDIM1.51(VSS13) JDIM1.52(VSS60) JDIM1.56(VSS61) JDIM1.57(VSS14) JDIM1.60(VSS62) JDIM1.61(VSS15) JDIM1.64(VSS63) JDIM1.65(VSS16) JDIM1.68(VSS64) JDIM1.69(VSS17) JDIM1.72(VSS65) JDIM1.73(VSS18) JDIM1.77(VSS19) JDIM1.78(VSS66) JDIM1.81(VSS20) JDIM1.82(VSS67) JDIM1.85(VSS21) JDIM1.86(VSS68) JDIM1.89(VSS22) JDIM1.90(VSS69) JDIM1.93(VSS23) JDIM1.94(VSS70) JDIM1.98(VSS71) JDIM1.99(VSS24) JDIM1.102(VSS72) JDIM1.103(VSS25) JDIM1.106(VSS73) JDIM1.107(VSS26) JDIM1.167(VSS27) JDIM1.168(VSS74) JDIM1.171(VSS28) JDIM1.172(VSS75) JDIM1.175(VSS29) JDIM1.176(VSS76) JDIM1.180(VSS77) JDIM1.181(VSS30) JDIM1.184(VSS78) JDIM1.185(VSS31) JDIM1.188(VSS79) JDIM1.189(VSS32) JDIM1.192(VSS80) JDIM1.193(VSS33) JDIM1.196(VSS81) JDIM1.197(VSS34) JDIM1.201(VSS35) JDIM1.202(VSS82) JDIM1.205(VSS36) JDIM1.206(VSS83) JDIM1.209(VSS37) JDIM1.210(VSS84) JDIM1.213(VSS38) JDIM1.214(VSS85) JDIM1.217(VSS39) JDIM1.218(VSS86) JDIM1.222(VSS87) JDIM1.223(VSS40) JDIM1.226(VSS88) JDIM1.227(VSS41) JDIM1.230(VSS89) JDIM1.231(VSS42) JDIM1.234(VSS90) JDIM1.235(VSS43) JDIM1.238(VSS91) JDIM1.239(VSS44) JDIM1.243(VSS45) JDIM1.244(VSS92) JDIM1.247(VSS46) JDIM1.248(VSS93) JDIM1.251(VSS47) JDIM1.252(VSS94) JDIM1.261(GND#1) JDIM1.262(GND#2) L8.1 PC1.2 PC2.2 PC3.2 PC4.2 PC5.2 PC6.2 PC7.1 PC8.2 PC9.2 PC10.2 PC12.2 PC13.2 PC14.2 PC15.2 PC16.2 PC17.2 PC18.2 PC19.2 PC20.2 PC21.2 PC23.1 PC24.2 PC25.1 PC28.1 PC29.2 PC30.2 PC32.2 PC33.2 PC34.2 PC35.2 PC36.2 PC37.2 PC38.2 PC39.2 PC40.2 PC41.2 PC42.2 PC43.2 PC45.1 PC47.2 PC48.2 PC50.2 PC52.2 PC53.2 PC54.2 PC56.2 PC58.2 PC59.1 PC60.2 PC61.1 PC62.2 PC63.2 PC64.2 PC65.2 PC66.2 PC68.2 PC69.2 PC70.2 PC71.2 PC72.2 PC73.2 PC74.2 PC75.2 PC76.1 PC78.1 PC79.2 PC80.2 PC81.2 PC82.1 PC83.2 PC84.2 PC86.2 PC87.2 PC88.2 PC89.2 PC90.2 PC91.2 PC92.2 PC93.2 PC94.2 PC96.2 PC97.2 PC98.1 PC99.2 PC100.1 PC101.2 PC102.2 PC103.2 PC104.2 PC106.1 PC107.2 PC108.2 PC109.2 PC110.1 PC111.1 PC112.2 PC113.2 PC114.2 PC115.2 PC116.2 PC117.2 PC118.2 PC119.2 PC120.1 PC121.1 PC122.2 PC124.2 PC125.2 PC126.2 PC127.2 PC128.2 PC129.2 PC130.2 PC131.2 PC132.2 PC133.1 PC134.2 PC136.2 PC137.2 PC138.2 PC140.2 PC141.2 PC142.2 PC144.1 PC145.1 PC146.2 PC147.2 PC148.2 PC149.1 PC150.2 PC151.2 PC152.2 PC153.2 PC154.2 PC155.2 PC156.2 PC157.2 PC158.2 PC159.2 PC160.2 PC161.2 PC162.2 PC163.2 PC164.2 PC165.2 PC166.2 PC167.2 PC168.2 PC169.2 PC170.2 PC171.2 PC172.2 PC173.2 PC174.2 PC175.2 PC176.2 PC178.2 PC179.2 PC180.2 PC181.2 PC182.2 PC183.2 PC184.2 PC186.2 PC187.2 PC188.2 PC191.1 PC192.1 PC193.2 PC194.1 PC196.2 PC197.2 PC198.2 PC199.2 PC200.2 PC201.2 PC202.1 PC203.2 PC204.2 PC205.1 PC206.1 PC207.2 PC208.2 PC209.1 PC210.2 PC211.2 PC212.2 PC213.2 PC214.2 PC215.1 PC216.2 PC218.1 PC219.2 PC220.2 PC221.2 PC223.2 PC224.2 PC225.2 PC226.2 PC227.2 PC228.2 PC229.2 PC230.2 PC231.2 PC232.2 PC233.2 PC234.2 PC235.2 PC236.2 PC237.2 PD1.2 PD2.2 PD3.2 PJ5.1 PJ5.2 PJ16.1 PJ16.2 PJ16.9 PJ16.10 PQ1.1(S) PQ3.1(S) PQ4.1(EMITTER) PQ5.1(S) PQ7.1(S) PQ8.1(S) PQ9.1(S) PQ11.1(S) PQ12.1(EMITTER) PQ15.1(S1) PQ15.2(S2) PQ15.3(S3) PQ16.1(S1) PQ16.2(S2) PQ16.3(S3) PQ20.1(S1) PQ20.2(S2) PQ20.3(S3) PQ22.1(S1) PQ22.2(S2) PQ22.3(S3) PQ24.1(S) PR2.1 PR20.2 PR27.2 PR35.2 PR39.2 PR42.2 PR46.2 PR52.2 PR62.2 PR74.1 PR82.2 PR83.2 PR88.2 PR90.2 PR101.2 PR113.2 PR115.2 PR123.1 PR126.2 PR133.2 PR139.1 PR149.2 PR162.2 PR177.2 PR195.2 PR196.2 PR197.2 PR213.2 PR216.2 PR223.2 PR227.2 PR230.1 PR234.1 PR236.1 PR239.2 PR242.1 PR250.2 PR254.2 PR260.2 PU1.29(GND) PU2.22(GND#1) PU2.29(GND#2) PU2.30(GND#3) PU2.31(GND#4) PU2.32(GND#5) PU2.33(GND#6) PU2.34(GND#7) PU2.35(GND#8) PU2.36(GND#9) PU2.37(GND#10) PU2.38(GND#11) PU3.2(GND) PU4.11(GND#1) PU4.15(GND#2) PU5.2(GND) PU5.4(HYST) PU6.12(PGND#1) PU6.13(PGND#2) PU6.14(PGND#3) PU6.15(PGND#4) PU6.19(PGND#5) PU7.11(GND) PU8.4(AGND) PU8.5(PGND) PU8.11(EPAD#1) PU8.12(EPAD#2) PU8.13(EPAD#3) PU8.14(EPAD#4) PU8.15(EPAD#5) PU8.16(EPAD#6) PU9.11(GND#1) PU9.15(GND#2) PU10.29(GND) PU11.2(GND) PU12.8(GND#1) PU12.9(GND#2) PU13.4(PGND) PU13.8(AGND) PU14.4(PGND) PU14.8(AGND) PU15.1(VTTGND) PU15.14(PGND) PU15.21(PAD) Q2.1(S) Q2.4(S) Q4.1(S) Q5.1(EMITTER) Q7.1(S) Q7.4(S) Q15.1(S) Q15.4(S) Q16.1(S) Q16.4(S) Q18.1(S) Q19.1(S) Q21.1(S) Q22.1(S) Q23.1(S) Q23.4(S) Q24.1(S) Q26.1(S) Q26.4(S) Q27.1(EMITTER) Q30.1(S) Q31.1(S) Q31.4(S) Q33.1(S) Q34.1(S) Q35.1(S) Q35.4(S) R1.2 R20.2 R25.2 R28.2 R40.1 R44.1 R45.2 R47.1 R48.2 R53.1 R59.1 R62.2 R66.1 R67.1 R70.2 R73.1 R74.2 R77.1 R84.1 R87.1 R88.2 R90.1 R91.1 R96.2 R97.2 R98.2 R101.2 R102.2 R110.2 R113.2 R118.1 R131.1 R133.1 R138.1 R139.1 R142.1 R144.2 R145.2 R147.2 R150.1 R151.1 R155.1 R159.1 R163.2 R165.1 R167.1 R170.2 R171.1 R175.2 R177.2 R183.2 R191.1 R192.1 R193.2 R200.1 R205.1 R227.2 R233.1 R242.2 R243.2 R248.2 R249.1 R264.2 R275.2 R283.2 R295.1 R297.1 R299.2 R309.1 R313.2 R314.2 R315.1 R316.2 R317.2 R318.2 R319.2 R334.2 R346.2 R347.2 R361.1 R377.1 R385.2 R396.1 R399.2 R415.1 R428.1 R429.1 R430.1 R443.1 R461.2 R473.1 R477.1 R478.1 R480.2 R481.1 R484.1 R488.1 R490.1 R493.1 R502.1 R504.1 R505.1 R507.2 R508.2 R518.2 R520.2 R529.1 R531.2 R533.2 R543.2 R546.2 R550.2 R555.2 R556.2 R557.2 R562.2 R565.2 R566.2 R568.2 R574.2 R575.2 R577.2 R579.2 R581.2 R586.2 R594.1 R603.2 R624.2 R633.1 R634.1 SPAD1.1 SPAD2.1 SPAD3.1 SPAD4.1 SPAD5.1 SPAD6.1 SPAD7.1 SPAD8.1 SPAD9.1 SPAD10.1 SW1.1 SW1.2 SW1.5 SW1.6 SW3.1 SW3.2 SW3.5 SW3.6 U1.3(GND1) U1.8(GND2) U2.3(GND1) U2.8(GND2) U3.33(GND) U4.2(GND) U5.9(GND#1) U5.11(GND#2) U6.49(EPAD) U7.2(GND) U8.9(GND#1) U8.11(GND#2) U9.A2(VSSQ#A2) U9.A8(VSSQ#A8) U9.B2(VSS#B2) U9.C9(VSSQ#C9) U9.D2(VSSQ#D2) U9.D8(VSSQ#D8) U9.E1(VSS#E1) U9.E3(VSSQ#E3) U9.E8(VSSQ#E8) U9.F1(VSSQ#F1) U9.G8(VSS#G8) U9.H1(VSSQ#H1) U9.H9(VSSQ#H9) U9.K1(VSS#K1) U9.K9(VSS#K9) U9.N1(VSS#N1) U9.N9(TEN) U9.T1(VSS#T1) U10.2(GND) U11.25(GND_PAD) U12.2(GND) U13.A2(VSSQ#A2) U13.A8(VSSQ#A8) U13.B2(VSS#B2) U13.C9(VSSQ#C9) U13.D2(VSSQ#D2) U13.D8(VSSQ#D8) U13.E1(VSS#E1) U13.E3(VSSQ#E3) U13.E8(VSSQ#E8) U13.F1(VSSQ#F1) U13.G8(VSS#G8) U13.H1(VSSQ#H1) U13.H9(VSSQ#H9) U13.K1(VSS#K1) U13.K9(VSS#K9) U13.N1(VSS#N1) U13.N9(TEN) U13.T1(VSS#T1) U14.1(VSS_2) U14.27(VSS_3) U14.49(VSS_4) U14.91(VSS_5) U14.104(VSS_1) U15.2(GND) U16.49(DGND) U17.5(GND#1) U17.10(RES) U17.12(GND#2) U17.13(ADC3) U17.15(ADC2) U17.16(ADC1) U18.2(GND) U19.2(GND) U20.25(GND) U21.4(VSS) U22.A3(VSS6) U22.A6(VSS13) U22.A12(VSS1) U22.A16(VSS2) U22.A20(VSS3) U22.A24(VSS4) U22.A28(VSS5) U22.A32(VSS7) U22.A36(VSS8) U22.A40(VSS9) U22.A44(VSS10) U22.A48(VSS11) U22.A51(VSS12) U22.AA12(VSS14) U22.AA13(VSS15) U22.AA15(VSS16) U22.AA17(VSS17) U22.AA21(VSS18) U22.AA23(VSS19) U22.AA25(VSS20) U22.AA27(VSS21) U22.AA35(VSS22) U22.AA43(VSS23) U22.AA48(VSS24) U22.AB1(VSS25) U22.AB3(VSS26) U22.AB55(VSS27) U22.AC8(VSS33) U22.AC13(VSS28) U22.AC23(VSS29) U22.AC25(VSS30) U22.AC27(VSS31) U22.AC29(VSS32) U22.AE18(VSS34) U22.AE23(VSS35) U22.AE25(VSS36) U22.AE27(VSS37) U22.AE43(VSS38) U22.AE48(VSS39) U22.AF1(VSS40) U22.AF3(VSS49) U22.AF4(VSS50) U22.AF6(VSS61) U22.AF8(VSS62) U22.AF9(VSS63) U22.AF11(VSS41) U22.AF12(VSS42) U22.AF14(VSS43) U22.AF16(VSS44) U22.AF18(VSS45) U22.AF23(VSS46) U22.AF25(VSS47) U22.AF29(VSS48) U22.AF40(VSS51) U22.AF42(VSS52) U22.AF44(VSS53) U22.AF45(VSS54) U22.AF47(VSS55) U22.AF48(VSS56) U22.AF50(VSS57) U22.AF52(VSS58) U22.AF53(VSS59) U22.AF55(VSS60) U22.AG20(VSS64) U22.AG25(VSS65) U22.AG29(VSS66) U22.AG35(VSS67) U22.AG38(VSS68) U22.AJ8(VSS77) U22.AJ13(VSS69) U22.AJ18(VSS70) U22.AJ25(VSS71) U22.AJ29(VSS72) U22.AJ36(VSS73) U22.AJ38(VSS74) U22.AJ39(VSS75) U22.AJ44(VSS76) U22.AK1(VSS78) U22.AK3(VSS79) U22.AK55(VSS80) U22.AL3(VSS90) U22.AL7(VSS97) U22.AL8(VSS98) U22.AL10(VSS81) U22.AL12(VSS82) U22.AL13(VSS83) U22.AL15(VSS84) U22.AL17(VSS85) U22.AL20(VSS86) U22.AL21(VSS87) U22.AL23(VSS1) U22.AL25(VSS88) U22.AL29(VSS89) U22.AL39(VSS91) U22.AL41(VSS92) U22.AL43(VSS93) U22.AL44(VSS94) U22.AL46(VSS95) U22.AL51(VSS96) U22.AM1(VSS99) U22.AM21(VSS100) U22.AM23(VSS101) U22.AM25(VSS102) U22.AM29(VSS103) U22.AM31(VSS104) U22.AM38(VSS105) U22.AM55(VSS106) U22.AN3(VSS108) U22.AN8(VSS110) U22.AN10(VSS107) U22.AN46(VSS109) U22.AN48(VSS_111) U22.AN49(VSS_112) U22.AN51(VSS_113) U22.AN53(VSS_114) U22.AP23(VSS_115) U22.AP27(VSS_116) U22.AP28(VSS_117) U22.AP29(VSS_118) U22.AP33(VSS_119) U22.AP35(VSS_120) U22.AR2(VSS_124) U22.AR7(VSS_130) U22.AR10(VSS_121) U22.AR12(VSS_122) U22.AR17(VSS_123) U22.AR39(VSS_125) U22.AR44(VSS_126) U22.AR46(VSS_127) U22.AR49(VSS_128) U22.AR54(VSS_129) U22.AT23(VSS_131) U22.AT33(VSS_132) U22.AU3(VSS_135) U22.AU10(VSS_133) U22.AU28(VSS_134) U22.AU46(VSS_136) U22.AU53(VSS_137) U22.AV15(VSS_138) U22.AV17(VSS_139) U22.AV23(VSS_140) U22.AV25(VSS_141) U22.AV31(VSS_142) U22.AV33(VSS_143) U22.AV39(VSS_144) U22.AV41(VSS_145) U22.AW2(VSS_147) U22.AW5(VSS_150) U22.AW10(VSS_146) U22.AW28(VSS_148) U22.AW46(VSS_149) U22.AW51(VSS_151) U22.AW54(VSS_152) U22.AY13(VSS_153) U22.AY15(VSS_154) U22.AY28(VSS_155) U22.AY41(VSS_156) U22.AY43(VSS_157) U22.B2(VSS_158) U22.B55(VSS_159) U22.BA27(VSS_160) U22.BA29(VSS_161) U22.BB1(VSS_162) U22.BB28(VSS_163) U22.BB55(VSS_164) U22.BC5(VSS_178) U22.BC11(VSS_165) U22.BC17(VSS_166) U22.BC19(VSS_167) U22.BC21(VSS_168) U22.BC23(VSS_169) U22.BC25(VSS_170) U22.BC31(VSS_171) U22.BC33(VSS_172) U22.BC35(VSS_173) U22.BC37(VSS_174) U22.BC39(VSS_175) U22.BC41(VSS_176) U22.BC45(VSS_177) U22.BC51(VSS_179) U22.BD9(VSS_187) U22.BD15(VSS_180) U22.BD19(VSS_181) U22.BD21(VSS_182) U22.BD28(VSS_183) U22.BD35(VSS_184) U22.BD37(VSS_185) U22.BD47(VSS_186) U22.BE3(VSS_189) U22.BE28(VSS_188) U22.BE53(VSS_190) U22.BF9(VSS_194) U22.BF19(VSS_191) U22.BF37(VSS_192) U22.BF47(VSS_193) U22.BG1(VSS_195) U22.BG6(VSS_199) U22.BG28(VSS_196) U22.BG50(VSS_197) U22.BG55(VSS_198) U22.BH11(VSS_200) U22.BH13(VSS_201) U22.BH17(VSS_202) U22.BH19(VSS_203) U22.BH23(VSS_204) U22.BH25(VSS_205) U22.BH28(VSS_206) U22.BH31(VSS_207) U22.BH33(VSS_208) U22.BH37(VSS_209) U22.BH39(VSS_210) U22.BH41(VSS_211) U22.BH45(VSS_212) U22.BJ2(VSS_215) U22.BJ15(VSS_213) U22.BJ19(VSS_214) U22.BJ25(VSS_216) U22.BJ28(VSS_217) U22.BJ31(VSS_218) U22.BJ37(VSS_219) U22.BJ41(VSS_220) U22.BJ54(VSS2) U22.BK1(VSS3) U22.BK17(VSS4) U22.BK21(VSS5) U22.BK35(VSS6) U22.BK39(VSS7) U22.BK55(VSS8) U22.BL5(VSS17) U22.BL8(VSS19) U22.BL10(VSS9) U22.BL14(VSS10) U22.BL24(VSS11) U22.BL28(VSS12) U22.BL32(VSS13) U22.BL42(VSS14) U22.BL46(VSS15) U22.BL48(VSS16) U22.BL51(VSS18) U22.C1(VSS20) U22.C12(VSS21) U22.C16(VSS22) U22.C28(VSS23) U22.C36(VSS24) U22.D6(VSS30) U22.D9(VSS31) U22.D21(VSS25) U22.D28(VSS26) U22.D41(VSS27) U22.D45(VSS28) U22.D55(VSS29) U22.E28(VSS32) U22.E50(VSS33) U22.E55(VSS34) U22.F1(VSS35) U22.F4(VSS38) U22.F21(VSS36) U22.F31(VSS37) U22.G28(VSS39) U22.H13(VSS40) U22.H15(VSS41) U22.H21(VSS42) U22.H23(VSS43) U22.H28(VSS44) U22.H33(VSS45) U22.H39(VSS46) U22.J8(VSS52) U22.J27(VSS47) U22.J33(VSS48) U22.J41(VSS49) U22.J45(VSS50) U22.J51(VSS51) U22.K1(VSS53) U22.K3(VSS55) U22.K28(VSS54) U22.K55(VSS56) U22.L5(VSS59) U22.L7(VSS60) U22.L8(VSS61) U22.L19(VSS57) U22.L33(VSS58) U22.M15(VSS62) U22.M25(VSS63) U22.M28(VSS64) U22.M35(VSS65) U22.M41(VSS66) U22.N12(VSS67) U22.N28(VSS68) U22.N46(VSS69) U22.N51(VSS70) U22.P21(VSS71) U22.P55(VSS72) U22.R8(VSS74) U22.R28(VSS73) U22.T3(VSS76) U22.T27(VSS75) U22.T38(VSS77) U22.U3(VSS79) U22.U13(VSS78) U22.V27(VSS80) U22.V38(VSS81) U22.V55(VSS82) U22.W2(VSS84) U22.W3(VSS85) U22.W5(VSS93) U22.W7(VSS95) U22.W8(VSS96) U22.W10(VSS83) U22.W39(VSS86) U22.W41(VSS87) U22.W43(VSS88) U22.W44(VSS89) U22.W46(VSS90) U22.W48(VSS91) U22.W49(VSS92) U22.W51(VSS94) U22.Y21(VSS97) U22.Y23(VSS98) U22.Y25(VSS99) U22.Y27(VSS100) U22.Y31(VSS101) U23.2(GND) U24.2(GND) U25.A2(VSSQ#A2) U25.A8(VSSQ#A8) U25.B2(VSS#B2) U25.C9(VSSQ#C9) U25.D2(VSSQ#D2) U25.D8(VSSQ#D8) U25.E1(VSS#E1) U25.E3(VSSQ#E3) U25.E8(VSSQ#E8) U25.F1(VSSQ#F1) U25.G8(VSS#G8) U25.H1(VSSQ#H1) U25.H9(VSSQ#H9) U25.K1(VSS#K1) U25.K9(VSS#K9) U25.N1(VSS#N1) U25.N9(TEN) U25.T1(VSS#T1) U26.C4(VSSQ#1) U26.E7(VSS#1) U26.G5(VSS#2) U26.H10(VSS#3) U26.K8(VSS#4) U26.N2(VSSQ#2) U26.N5(VSSQ#3) U26.P4(VSSQ#4) U26.P6(VSSQ#5) U27.2(GND) U28.9(GND1) U28.16(GND2) U28.23(GND3) U28.32(GND4) U28.33(EPAD) U29.4(GND) U30.A2(VSSQ#A2) U30.A8(VSSQ#A8) U30.B2(VSS#B2) U30.C9(VSSQ#C9) U30.D2(VSSQ#D2) U30.D8(VSSQ#D8) U30.E1(VSS#E1) U30.E3(VSSQ#E3) U30.E8(VSSQ#E8) U30.F1(VSSQ#F1) U30.G8(VSS#G8) U30.H1(VSSQ#H1) U30.H9(VSSQ#H9) U30.K1(VSS#K1) U30.K9(VSS#K9) U30.N1(VSS#N1) U30.N9(TEN) U30.T1(VSS#T1) U31.5(GND#1) U31.6(GND#2) U31.7(GND#3) U31.8(GND#4) U32.3(GND#1) U32.13(GND#2) U32.21(GND#3) U32.22(GND#4) U32.23(GND#5) U32.24(GND#6) U32.25(GND#7) U33.2(GND) U34.3(GND) Y1.2 Y1.4 Y3.2 Y3.4
GND_VCGI: PC45.2 PC46.2 PR49.2 PU10.22(RGND)
GND_VNN: PC44.2 PC192.2 PR61.1 PU1.22(RGND)
PVCC2: PC23.2 PR13.2 PU10.12(PVCC)
V3A_BOOT: PR72.2 PU13.1(BOOT)
V3A_BOOT_R: PC55.1 PR72.1
V3A_EN: PC205.2 PR230.2 PR232.1 PU13.6(EN)
V3A_PWRGD: PR228.1 PU13.7(PGOOD)
V3A_VBYP: PC201.1 PR71.2 PR226.2 PU13.11(LDO3)
V3A_VOUT: PC202.2 PR75.2 PR76.2 PR209.2 PU13.10(VOUT)
V5P5A_BOOT: PR84.2 PU14.1(BOOT)
V5P5A_BOOT_R: PC67.1 PR84.1
V5P5A_EN: PC215.2 PR233.1 PR234.2 PU14.6(EN)
V5P5A_PWRGD: PR235.1 PU14.7(PGOOD)
V5P5A_VOUT: PC218.2 PR237.2 PR238.2 PR255.2 PU14.10(VOUT)
VCC_SPI: C426.2 R538.1 R541.1 R542.1 R547.1 U29.8(VCC)
VCC_VCCGI: PC181.1 PR38.2 PU10.1(VCC)
VCC_VNN: PC43.1 PR206.1 PU1.1(VCC)
VCCDSW: R290.2 U14.83(EGCS#/GPE2)
VCCGI_SENSE: PR3.1 PR58.1 U22.AG41(VCC_VCG_SENSE)
VCCGISS_SENSE: PR2.2 PR49.1 U22.AG39(VSS_VCG_SENSE)
VCCRTC_2: CN14.1 Q28.1(EMITTER) R387.1
VCCRTC_3: Q28.3(COLLECTOR) R388.2
VCCRTC_4: R388.1 R389.2
VDD10: C334.1 C336.1 C338.1 C339.1 C340.1 C341.1 C347.2 R406.1 U3.3(AVDD10#1) U3.8(AVDD10#2) U3.22(DVDD10) U3.30(AVDD10#3)
VDDI_DSC: C159.2 U26.C2(VDDI)
VDDREG/VDD33: R49.2 R50.1 U3.23(VDDREG)
1P35V_BOOT: PR247.2 PU15.18(BOOT)
1P35V_CS: PR242.2 PU15.13(CS)
1P35V_FB: PR250.1 PR251.2 PU15.6(FB)
1P35V_LGATE: PQ20.4(G) PU15.15(LGATE)
1P35V_PGOOD: PR245.1 PU15.10(PGOOD)
1P35V_PHASE: PC222.1 PL9.1 PQ20.5(D) PQ21.1(S1) PQ21.2(S2) PQ21.3(S3) PR85.1 PU15.16(PHASE)
1P35V_S3: PC223.1 PR248.2 PR249.1 PU15.7(S3)
1P35V_S5: PC221.1 PR246.1 PR248.1 PU15.8(S5)
1P35V_TON: PR243.2 PU15.9(TON)
1P35V_UGATE: PQ21.4(G) PU15.17(UGATE)
1P35V_VDD: PC220.1 PR241.2 PU15.12(VDD)
1P35V_VDDQ: PR251.1 PR252.2 PU15.5(VDDQ)
1P35V_VID: PR239.1 PR240.1 PU15.11(VID)
2ND_MBCLK: R234.1 U14.115(SMCLK1/GPC1) U27.1(SMBCLK)
2ND_MBDATA: R262.1 U14.116(SMDAT1/GPC2) U27.5(SMBDATA)
680_LDO: C208.1 PR71.1 R254.2 U12.1(VIN)
5671EN_1.24V: PC142.1 PR148.2 PU7.5(EN)
5671FB_1.24V: PC143.2 PR145.2 PR149.1 PU7.6(FB)
5671FB_1.24V_S: PC143.1 PR144.2 PR145.1
5671LX_1.24V: PL5.1 PR170.1 PU7.1(NC#1) PU7.2(SW#1) PU7.3(SW#2)
5671NC_1.24V: PC150.1 PU7.7(NC#2)
5671PG_1.24V: PR147.1 PU7.4(POK)
5671SVIN_1.24V: PC151.1 PR167.2 PU7.8(VCC)
24780_ACDET: PR123.2 PR128.2 PU2.6(ACDET)
24780_ACDRV: PR15.2 PU2.4(ACDRV)
24780_ACN: PC105.2 PC109.1 PR164.1 PU2.1(ACN)
24780_ACP: PC105.1 PC110.2 PR163.1 PU2.2(ACP)
24780_BATDRV: PR96.1 PU2.18(BATDRV)
24780_BATSRC: PR94.2 PU2.17(BATSRC)
24780_BM#: PR89.1 PU2.16(T\B\_\S\T\A\T\)
24780_BST: PR104.2 PU2.25(BTST)
24780_CMPIN: PR101.1 PU2.13(CMPIN)
24780_CMPOUT: PR97.1 PU2.14(CMPOUT)
24780_CMSRC: PR121.2 PU2.3(CMSRC)
24780_DH: PQ23.4(G) PU2.26(HIDRV)
24780_DL: PQ22.4(G) PU2.23(LODRV)
24780_ILIM: PC82.2 PR87.1 PR88.1 PU2.21(ILIM)
24780_LX: PC95.1 PL10.1 PQ22.5(D) PQ23.1(S1) PQ23.2(S2) PQ23.3(S3) PR86.1 PU2.27(PHASE)
24780_SRN: PC77.1 PC78.2 PR93.1 PR256.2
24780_SRP: PC76.2 PC77.2 PR92.1 PR257.2
24780_VCC: PC99.1 PR125.1 PU2.28(VCC)
61087COMP: PU8.1(COMP) R494.2
61087EN: C395.2 PU8.3(EN) R498.2 R499.2
61087FB: PU8.2(FB) R493.2 R500.1
61087FREQ: PU8.9(FREQ) R474.1 R478.2
61087SS: C391.2 PU8.10(SS)
61087SW: D39.2(ANODE) L12.2 PU8.6(SW#1) PU8.7(SW#2)
+601_VCC: C449.2 C450.2 C463.2 C464.2 C465.2 R563.1 R564.1 R567.1 R569.1 R576.1 R578.1 R580.1 R582.2 U32.6(VDD#1) U32.16(VDD#2)
+AZA_VDD: C267.1 C305.1 C306.1 R348.1 R349.2 U16.1(DVDD) U16.36(CPVDD)
+G_SEN_PW: C297.1 C323.1 R337.2 R374.2 R376.2 U17.1(VDD_IO) U17.8(CS) U17.14(VDD)
+LCDVCC_1: C61.2 R63.2 U7.1(OUT)
+SMDDR_VREF_DQ1_M1: C196.2 C201.2 C243.2 C244.1 C403.2 C404.2 C405.2 C423.2 C425.1 R299.1 R512.2 R516.2 U9.M1(VREFCA) U13.M1(VREFCA) U25.M1(VREFCA) U30.M1(VREFCA)
+TPVDD_1: C473.1 C480.1 C482.1 CN12.1 Q17.2(G) Q36.3(D) R352.2 R353.2 R359.2 R369.2 R602.2 R611.2 R612.2
+VNN: C122.1 C135.1 C136.1 C142.1 C143.1 C144.1 C158.2 C160.2 C165.2 C171.2 C174.2 C179.2 C180.2 C181.2 C182.2 PC24.1 PC25.2 PC29.1 PC30.1 PC34.1 PC35.1 PC39.1 PC40.1 PC149.2 PC153.1 PC154.1 PC157.1 PC158.1 PC166.1 PC167.1 PC175.1 PC176.1 PL4.2 PR11.1 PR40.2 U22.AF35(VNN1) U22.AG27(VNN2) U22.AG28(VNN3) U22.AG36(VNN4) U22.AG46(VNN5) U22.AG48(VNN6) U22.AJ27(VNN7) U22.AJ28(VNN8) U22.AJ46(VNN9) U22.AJ48(VNN10) U22.AL27(VNN11) U22.AL28(VNN12) U22.AL48(VNN13) U22.AL49(VNN14) U22.AM27(VNN15) U22.AM28(VNN16)
+VREF_CA_CPU: C470.1 R212.1 R587.1
+VREF_VCGI: PC188.1 PR155.2 PR169.1 PR172.1 PR201.2 PR207.1 PR208.1 PU10.17(VREF)
+VREF_VNN: PC48.1 PR16.2 PR30.1 PR31.1 PR65.1 PR66.1 PR67.1 PU1.17(VREF)
+VREFDQ_SB_M3: C410.1 R516.1 R519.1
ACCEL_INT2: R606.2 U17.9(INT2)
ACCEL_INTA: C304.2 Q21.2(G) U17.11(INT1)
ACIN: PR122.2 PR126.1 PR127.2 U14.72(ADC6/DSR1#/GPI6)
ACZ_SDIN: R365.1 U16.8(SDATA-IN)
ADOGND: C183.1 C188.1 C190.1 C195.1 C227.1 C247.1 C248.2 C263.2 C264.2 C265.1 C269.2 C270.2 C272.2 C284.1 C287.2 C294.1 CN8.5 D16.2 R227.1 R283.1 R293.1 R313.1 R315.2 R316.1 R317.1 R320.1 R347.1 U16.25(AVSS1) U16.38(AVSS2)
ALERT#: TP55.1 U27.3(ALERT#)
ALERT#_VCGI: PR171.1 PU10.5(A\L\E\R\T\)
ALERT#_VNN: PR186.1 PU1.5(A\L\E\R\T\)
AMP_MUTE#: D26.1(CATHODE) U14.109(TXD/SOUT0/GPB1)
AZ_CODEC_BITCLK: C353.2 R364.2 R425.2
AZ_CODEC_RST#: Q13.1(S) R427.1 U16.11(RESETB)
AZ_CODEC_SDIN0: R365.2 R408.1 R415.2 U22.B21(AVS_HDA_SDI)
AZ_CODEC_SDOUT: R426.2 U16.5(SDATA-OUT)
AZ_CODEC_SYNC: R414.2 U16.10(SYNC)
BAT-V: PC80.1 PC83.1 PC86.1 PC89.1 PC237.1 PJ16.7 PJ16.8 PR256.1 PR259.2
BATLED0#: R12.1 R15.1 U14.29(PWM3/GPA3)
BATLED1#: R3.1 R5.1 U14.25(PWM1/GPA1)
BEEP_1: C307.2 C316.2 R361.2 R363.1
BI#: PJ16.6 PR260.1 SW2.1 SW2.2
BI_GATE: C313.1 Q23.5(G) Q24.2(G) R356.1 SW3.3 SW3.4
BITCLK: C310.2 R364.1 U16.6(BCLK)
BL#: Q7.2(G) Q7.3(D) R126.1
BL_ENABLE: CN5.15 R450.1
BL_ON: D5.2(ANODE) Q5.3(COLLECTOR) Q7.6(D) R85.1 R450.2
BL_PWM_DIM: CN5.14 R451.1
BOARD_ID0: R501.1 R504.2 U22.AG53(GPIO_8)
BOARD_ID1: R157.1 R159.2 U22.AG54(GPIO_9)
BOARD_ID2: R151.2 R152.1 U22.AE54(GPIO_10)
BOARD_ID3: R505.2 R506.1 U22.AE53(GPIO_11)
BOARD_ID4: R502.2 R503.1 U22.AD55(GPIO_12)
BOARD_ID5: R149.1 R150.2 U22.AD53(GPIO_13)
BOARD_ID6: R139.2 R140.1 U22.AC54(GPIO_14)
BOARD_ID7: R137.1 R138.2 U22.AC53(GPIO_15)
BOARD_ID8: R130.1 R131.2 U22.AB53(GPIO_16)
BOOT_VCGI: PC26.1 PU10.8(BOOT)
BOOT_VNN: PC31.2 PU1.8(BOOT)
BT_EN: R561.1 U14.82(EGAD/GPE1)
BT_EN_R: CN10.54(W_DISABLE2#) R561.2
BVCCRTC_EXTPAD: C82.1 U22.J23(VCC_RTC_EXTPAD)
CARD_3V3: C462.2 C466.2 CN11.6(VDD) R574.1 U11.5(CARD_3V3)
CCD_PWR: C43.2 C51.1 CN5.8 CN5.9 R71.2
CHA_SA0: JDIM1.256(SA0) R318.1 R323.2
CHA_SA1: JDIM1.260(SA1) R319.1 R324.2
CHA_SA2: JDIM1.166(SA2) R333.2 R334.1
CLK_24M_DEBUG: C351.1 R421.1 R544.2 R545.2
CLK_24M_DEBUG_C: CN10.71(RESERVED1) R544.1
CLK_PCI_EC: R289.2 R441.1 U14.13(LPCCLK/GPM4)
CLK_PCIE_LANN: U3.16(REFCLK_N) U22.R5(PCIE_CLKOUT2N)
CLK_PCIE_LANP: U3.15(REFCLK_P) U22.R7(PCIE_CLKOUT2P)
CLK_PCIE_WLAN_REQ#_R: CN10.53(CLKREQ0#) Q38.1(S) R601.2 R616.2 U33.4(B1)
CLK_PCIE_WLANN: R600.2 U22.N10(PCIE_CLKOUT3N)
CLK_PCIE_WLANN_NGFF: CN10.49(REFCLKN0) R600.1
CLK_PCIE_WLANP: R599.2 U22.N8(PCIE_CLKOUT3P)
CLK_PCIE_WLANP_NGFF: CN10.47(REFCLKP0) R599.1
CLK_SCLK: C321.1 JDIM1.253(SCL) Q29.1(S) R373.1 R392.1
CLK_SDATA: C322.1 JDIM1.254(SDA) Q29.4(S) R375.1 R393.1
CLKRUN#: R282.1 R424.1 R539.1
CLR_CMOS: Q2.2(G) Q2.5(G) R298.1
CNVI_BRI_DT: R75.1 R84.2 U22.H17(CNV_BRI_DT)
CNVI_WT_RCOMP: R90.2 U22.F33(CNV_WT_RCOMP)
CODEC_VREF: C265.2 U16.28(VREF)
COMP_VCGI: PC185.1 PR204.2 PU10.23(COMP)
COMP_VNN: PC190.1 PR53.2 PU1.23(COMP)
CORE_PWROK: C78.2 R68.2 R74.1 R445.2 U22.D25(SOC_PWROK)
CSCL: R38.2 U6.29(CSCL)
CSDA: R27.2 U6.28(CSDA)
D/C#: PC106.2 PR112.2 TP44.1
DCIN_ENB: R48.1 U6.3(DCIN_ENB)
DDR4_SUSON_2V5: PR118.1 U14.126(GA20/GPB5)
DE1: R576.2 R577.1 U32.9(A_DE)
DE2: R578.2 R579.1 U32.8(B_DE)
DEW1: R568.1 R569.2 U32.20(B_EQ1)
DEW2: R562.1 R563.2 U32.17(B_EQ2)
DMIC_CLK: C320.1 D1.2 R55.1 R355.1
DMIC_CLK_C: CN5.40 R55.2
DMIC_CLK_R: R355.2 U16.3(GPIO1/DMIC-CLK)
DMIC_DAT: CN5.39 D2.2 R354.2
DMIC_DAT_R: R354.1 U16.2(GPIO0/DMIC-DATA)
DNBSWON#: R187.1 R261.2 U22.E54(P\M\U\_\P\W\R\B\T\N\)
DNBSWON#_R: R261.1 U14.123(CTX0/TMA0/GPB2)
DUALDMIC_PWR: CN5.12 R57.2 R58.2
EC_FPBACK#: Q5.2(BASE) U14.86(PS2DAT0/TMB1/GPF1)
EC_PWROK: R68.1 U14.33(GINT/CTS0#/GPD5)
ECAGND: C257.2 C261.1 L8.2 U14.75(AVSS)
EDP_AUXN: C386.1 R472.2 U22.W15(EDP_AUXN)
EDP_AUXN_C: C386.2 CN5.19
EDP_AUXP: C387.1 R473.2 U22.W17(EDP_AUXP)
EDP_AUXP_C: C387.2 CN5.18
EDP_HPD_R: C376.2 Q4.2(G) R67.2 R449.1
EDP_HPD_R_C: CN5.16 R449.2
EDP_RCOMP_N: R114.1 U22.AA7(E\D\P\_\R\C\O\M\P\)
EDP_RCOMP_P: R114.2 U22.AA5(EDP_RCOMP_P)
EDP_TXN0: C380.1 U22.AE13(EDP_TXN_0)
EDP_TXN0_C: C380.2 CN5.22
EDP_TXN1: C384.1 U22.AC17(EDP_TXN_1)
EDP_TXN1_C: C384.2 CN5.25
EDP_TXN2: C378.1 U22.AE8(EDP_TXN_2)
EDP_TXN2_C: C378.2 CN5.28
EDP_TXN3: C382.1 U22.AE7(EDP_TXN_3)
EDP_TXN3_C: C382.2 CN5.31
EDP_TXP0: C381.1 U22.AE12(EDP_TXP_0)
EDP_TXP0_C: C381.2 CN5.21
EDP_TXP1: C385.1 U22.AC15(EDP_TXP_1)
EDP_TXP1_C: C385.2 CN5.24
EDP_TXP2: C379.1 U22.AE10(EDP_TXP_2)
EDP_TXP2_C: C379.2 CN5.27
EDP_TXP3: C383.1 U22.AE5(EDP_TXP_3)
EDP_TXP3_C: C383.2 CN5.30
EDP_VDD_EN: R59.2 R620.2 U7.3(EN)
EMMC_CLK: U22.J13(EMMC_CLK) U26.M6(CLK)
EMMC_CMD: R198.2 U22.M13(EMMC_CMD) U26.M5(CMD)
EMMC_DATA_0: TP14.1 U22.M19(EMMC_D0) U26.A3(DAT0)
EMMC_DATA_1: U22.H19(EMMC_D1) U26.A4(DAT1)
EMMC_DATA_2: U22.J19(EMMC_D2) U26.A5(DAT2)
EMMC_DATA_3: U22.P17(EMMC_D3) U26.B2(DAT3)
EMMC_DATA_4: U22.P19(EMMC_D4) U26.B3(DAT4)
EMMC_DATA_5: U22.J15(EMMC_D5) U26.B4(DAT5)
EMMC_DATA_6: U22.L17(EMMC_D6) U26.B5(DAT6)
EMMC_DATA_7: U22.M17(EMMC_D7) U26.B6(DAT7)
EMMC_ID0: R133.2 R136.1 U22.AC39(GPIO_31)
EMMC_ID1: R527.1 R529.2 U22.AC44(GPIO_32)
EMMC_ID2: R155.2 R156.1 U22.AA44(GPIO_34)
EMMC_RCLK: R183.1 R188.2 U22.L15(EMMC_RCLK)
EMMC_RCLK_R: R188.1 U26.H5(DS/NC)
EMMC_RCOMP: R98.1 U22.L13(EMMC_RCOMP)
EMMC_RST: R190.1 U22.U44(E\M\M\C\_\R\S\T\)
EN: R580.2 R581.1 U32.7(EN)
EQ1: R564.2 R565.1 U32.18(A_EQ1)
EQ2: R566.1 R567.2 U32.19(A_EQ2)
EQ_SEL_A0: R43.2 R45.1 U6.5(EQ)
FAN1_DAC: U14.81(DAC5/RIG0#/GPJ5) U31.4(VSET)
FAN1_RPM: C434.2 CN9.2 R551.2 U14.47(TACH0A/GPD6)
FAN2_RPM: R251.1 U14.108(RXD/SIN0/GPB0)
FB_VCGI: PC185.2 PC189.2 PR204.1 PR214.1 PU10.24(FB)
FB_VNN: PC190.2 PC195.2 PR53.1 PR219.1 PU1.24(FB)
G5335-AGND-1: PC123.2 PC135.2 PR138.2 PR139.2 PR142.2 PU6.4(AGND)
G5335-BST-1: PR5.2 PU6.20(BST)
G5335-EN-1: PC135.1 PR6.1 PU6.2(EN)
G5335-FB-1: PC139.1 PR141.2 PR142.1 PU6.5(FB)
G5335-LX-1: PC11.1 PL3.1 PR132.1 PU6.10(LX#2) PU6.11(LX#3) PU6.16(LX#4) PU6.17(LX#5) PU6.18(LX#6) PU6.25(LX#1)
G5335-PFM-1: PR8.1 PR138.1 PU6.3(P\F\M\)
G5335-PWRGD-1: PR7.1 PU6.1(PGOOD)
G5335-SS-1: PC123.1 PU6.23(SS)
G5335-TON-1: PR146.1 PU6.6(TON)
G5335-VCC-1: PC122.1 PR4.2 PU6.21(VCC)
G5719LX1.8V: PL6.1 PU11.3(LX)
G5719LX2.5V: PL1.1 PU3.3(LX)
G_MBCLK_R: R373.2 R374.1 U17.4(SCL/SPC)
G_MBDATA_R: R375.2 R376.1 U17.6(SDA/SDI/SDO)
GPA5: TP39.1 U14.31(PWM5/GPA5)
GPC6: CN5.38 R221.2 R248.1 U14.124(TMR1/GPC6)
GPD7: TP40.1 U14.48(TACH1A/TMA1/GPD7)
GPE0: TP35.1 U14.19(L80HLAT/BAO/GPE0)
GPE7: TP36.1 U14.20(L80LLAT/GPE7)
GPF6: TP24.1 U14.117(SMCLK2/PECI/GPF6)
GPH0: R282.2 U14.93(CLKRUN#/GPH0/ID0)
GPH1: TP31.1 U14.94(CRX1/SIN1/SMCLK3/GPH1/ID1)
GPH2: TP30.1 U14.95(CTX1/SOUT1/SMDAT3/GPH2/ID2)
GPH3: TP29.1 U14.96(GPH3/ID3)
GPH4: TP25.1 U14.97(GPH4/ID4)
GPH5: R274.2 U14.98(GPH5/ID5)
GPH6: R260.2 U14.99(GPH6/ID6)
GPIO0: TP21.1 U11.17(GPIO0)
GPIO_27: R117.1 R118.2 U22.AE39(GPIO_27)
GPIO_28: R141.1 R142.2 U22.AE46(GPIO_28)
GPIO_43: R482.1 U22.T53(MDSI_C_TE)
GPIO_61: R490.2 R491.1 U22.N54(SIO_UART0_TXD)
GPIO_62: R480.1 U22.N53(S\I\O\_\U\A\R\T\0\_\R\T\S\)
GPIO_64: TP53.1 U22.M53(SIO_UART2_RXD)
GPIO_65: R488.2 R489.1 TP54.1 U22.L54(SIO_UART2_TXD)
GPIO_66: R476.1 R477.2 U22.K53(S\I\O\_\U\A\R\T\2\_\R\T\S\)
GPIO_79: R87.2 U22.M39(SIO_SPI_0_CLK)
GPIO_80: R62.1 U22.L37(SIO_SPI_0_FS0)
GPIO_81: R46.1 U22.J39(SIO_SPI_0_FS1)
GPIO_83: R72.1 R77.2 U22.J37(SIO_SPI_0_TXD)
GPIO_84: R51.1 R53.2 U22.M37(SIO_SPI_2_CLK)
GPIO_85: R102.1 U22.P33(SIO_SPI_2_FS0)
GPIO_86: R88.1 U22.P37(SIO_SPI_2_FS1)
GPIO_87: R70.1 U22.L35(SIO_SPI_2_FS2)
GPIO_89: R96.1 U22.M33(SIO_SPI_2_TXD)
GPIO_105: R106.2 U22.L46(GPIO_105)
GPIO_140: Q16.5(G) U22.J43(GPIO_140)
GPIO_141: Q15.5(G) U22.D43(GPIO_141)
GPIO_142: Q26.3(D) U22.F43(GPIO_142)
GPIO_159: R443.2 U22.C24(AVS_I2S0_SDI)
GPIO_163: R65.1 R73.2 U22.J21(AVS_I2S1_WS_SYNC)
GPIO_164: R91.2 U22.M21(AVS_I2S1_SDI)
GPIO_172: R416.1 R428.2 U22.C20(AVS_DMIC_CLK_B1)
GPIO_174: R418.1 R430.2 U22.C18(AVS_DMIC_CLK_AB2)
GPIO_175: R417.1 R429.2 U22.A18(AVS_DMIC_DATA_2)
GPIO_PWR: R99.1 R127.1 R132.1 R445.1 R446.1 R447.1 R452.1 R458.1 R459.1 R460.2 R463.1
GPJ1: R300.2 U14.77(GPJ1)
GPJ3: R297.2 R298.2 U14.79(DAC3/TACH1B/GPJ3)
GPU_CLK#_C: C72.1 U6.48(IN_CLKN)
GPU_CLK_C: C71.1 U6.47(IN_CLKP)
GPU_D0#_C: C57.1 U6.45(IN_D0N)
GPU_D0_C: C56.1 U6.44(IN_D0P)
GPU_D1#_C: C70.1 U6.42(IN_D1N)
GPU_D1_C: C69.1 U6.41(IN_D1P)
GPU_D2#_C: C55.1 U6.39(IN_D2N)
GPU_D2_C: C54.1 U6.38(IN_D2P)
GPU_DDCCLK_Q: Q32.3(D) R47.2 R436.2 R628.1 R631.1
GPU_DDCCLK_Q_R: R631.2 U6.34(SCL_SRC/AUXP)
GPU_DDCDATA_Q: Q32.6(D) R44.2 R435.2 R629.1 R630.1
GPU_DDCDATA_Q_R: R630.2 U6.33(SDA_SRC/AUXN)
GSENSOR_INT: Q22.3(D) R108.2 U22.AC46(GPIO_19)
H_CPU_SVIDCLK: PR18.2 PR29.2 PR166.2 PR181.2 R457.2 R462.2
H_CPU_SVIDDAT: PR26.2 PR33.2 PR179.2 PR192.2 R470.2 R471.2
H_PROCHOT#: PR107.2 PR189.2 PR191.2 PR202.2 Q34.3(D) R487.1 U22.J54(P\R\O\C\H\O\T\)
HDA_BCLK_R: R425.1 U22.A22(AVS_HDA_BCLK)
HDA_RST#_R: R427.2 U22.C21(A\V\S\_\H\D\A\_\R\S\T\)
HDA_SDO_R: R426.1 U22.C22(AVS_HDA_SDO)
HDA_SYNC_R: R414.1 U22.C23(AVS_HDA_WS_SYNC)
HDMI_5V: C332.1 CN1.18(+5V) EC5.2 U19.1(VOUT)
HDMI_DDCCLK_SW: Q32.4(S) R419.2 R436.1 U22.B43(DDI0_DDC_SCL)
HDMI_DDCDATA_SW: Q32.1(S) R435.1 R454.2 U22.C43(DDI0_DDC_SDA)
HDMI_HPD: C333.1 CN1.19(HP_DET) EC6.1 U6.21(HPD_SNK)
