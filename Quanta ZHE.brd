# Allegro board Quanta ZHE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_VCGI: length 5.3
  TOP w0.127: PC45.2 PC46.2 56.15,62.16 PR49.2 56.29,62.28 v1(56.29,63.55)
  BOTTOM w0.127: v1(56.29,63.55) 55.79,63.55 55.51,63.82 PU10.22
GND_VNN: length 5.9
  TOP w0.203: PR61.1 31.2,61.35 v1(31.2,61.52) 31.2,61.81 PC44.2 32.11,62.15 32.58,62.62 PU1.22
  BOTTOM w0.127: v1(31.15,62.66) 31.15,61.57 v1(31.2,61.52)
  BOTTOM w0.203: v1(31.2,61.52) 31.2,61.35 PR61.1 PC192.2
PVCC2: length 4.8
  TOP w0.508: PR13.2 57.02,72.02 56.28,71.29 PC23.2 55.79,70.92 v1(55.4,70.53)
  BOTTOM w0.203: 54.86,69.84 54.86,69.66 54.71,69.51 PU10.12
  BOTTOM w0.508: v1(55.4,70.53) 54.86,69.99 54.86,69.84
V3A_BOOT: length 2.5
  TOP w0.254: v1(155.77,48.99) 155.77,49.45 PR72.2
  BOTTOM w0.254: v1(155.77,48.99) 156.51,48.25 PU13.1
V3A_BOOT_R: length 2.5
  TOP w0.127: PR72.1 v1(155.23,52.25)
  TOP w0.508: PC55.1 155.86,51.23 155.83,51.19 PR72.1
V3A_EN: length 5.5
  BOTTOM w0.127: PU13.6 156.51,44.64 156.4,44.53 154.82,44.53 154.09,43.8 PC205.2 PR230.2 PR232.1
V3A_PWRGD: length 1.9
  BOTTOM w0.127: PR228.1 154.52,44.93 154.9,44.93 155.38,45.41 PU13.7
V3A_VBYP: length 6
  TOP w0.254: v1(154.72,48.69) 154.34,48.69 153.7,49.33 PR71.2
  BOTTOM w0.127: PU13.11 155.26,47.21 154.91,46.85 154.52,46.85 154.09,47.28 PC201.1 PR226.2 154.59,48.82 v1(154.72,48.69)
V3A_VOUT: length 31.2
  TOP w0.127: v1(154.72,46.41) 155.09,46.41 155.61,45.9 PR75.2 155.61,45.26 v1(155.1,44.75) 155.35,44.5 PR76.2
  IN3 w0.127: v1(154.72,46.41) 155.27,46.96 158.32,46.96 158.41,47.05 158.41,48.06 159.51,49.15 159.51,58.48 159.24,58.75 152.98,58.75 152.55,59.18 v1(152.55,61.14)
  BOTTOM w0.127: PU13.10 155.26,46.76 154.91,46.41 v1(154.72,46.41) 154.21,46.41 PC202.2 ; v1(152.55,61.14) 152.55,61.3 153.03,61.78 PR209.2
V5P5A_BOOT: length 4
  TOP w0.508: PR84.2 v1(165.8,28.33) 165.26,28.88 v1(165.26,29.13)
  BOTTOM w0.203: PU14.1 163.64,29.49 164.62,29.49 164.79,29.32 165.07,29.32 v1(165.26,29.13)
V5P5A_BOOT_R: length 2.4
  TOP w0.127: PR84.1 166.78,26.34 v1(167.04,26.08)
  TOP w0.508: PR84.1 166.15,27.14 166.11,27.1 PC67.1
V5P5A_EN: length 3.6
  BOTTOM w0.127: PR233.1 PR234.2 PC215.2 164.21,33.17 163.58,33.17 163.47,33.06 PU14.6
V5P5A_PWRGD: length 3.3
  BOTTOM w0.127: PR235.1 166.65,33.52 166.22,33.09 166.22,32.78 166.07,32.64 v1(165.43,32.64) 165.08,32.29 PU14.7
V5P5A_VOUT: length 17.6
  IN1 w0.254: v1(167.93,29.26) 168.28,28.9 168.28,21.95 167.82,21.49 167.6,21.49 167.28,21.17 167.28,20.08 167.06,19.86 v1(166.02,19.86)
  BOTTOM w0.203: PR237.2 165.48,30.94 PU14.10
  BOTTOM w0.254: PR255.2 165.78,19.86 v1(166.02,19.86) ; v1(167.93,29.26) 166.78,29.26 166.65,29.39 PC218.2 PR238.2 165.65,30.78 PR237.2
VCC_SPI: length 26.4
  IN1 w0.381: v1(37.5,41.71) 37.23,41.98 37.23,45.38 v1(38.89,47.04)
  IN2 w0.381: v1(26.32,47.93) 27.21,47.04 v1(38.89,47.04)
  BOTTOM w0.381: R547.1 37.5,42.2 v1(37.5,41.71) 37.5,41.32 37.74,41.07 C426.2 ; R542.1 37.36,46.32 38.14,47.1 R538.1 38.76,47.17 v1(38.89,47.04) ; R541.1 25.43,47.04 v1(26.32,47.93) 27.16,47.09 U29.8
VCC_VCCGI: length 7.2
  TOP w0.127: v1(50.83,64.23) 50.63,64.44 v1(49.82,64.44) PR38.2
  BOTTOM w0.127: v1(50.83,64.23) 50.41,64.23 PC181.1 50.5,64.74 51.32,64.74 51.95,65.36 PU10.1
VCC_VNN: length 5.6
  TOP w0.203: PC43.1 37.37,63.04 v1(36.93,63.49) 36.07,64.35 PU1.1
  TOP w0.254: PC43.1 37.74,62.87 38.16,62.46 39.45,62.46 v1(39.58,62.33)
  BOTTOM w0.254: PR206.1 39.28,62.62 v1(39.58,62.33)
VCCDSW: length 3.2
  TOP w0.14: U14.83 39.29,33.18 39.53,32.94 v1(40.6,32.94) R290.2
VCCGI_SENSE: length 87.9
  TOP w0.14: PR3.1 64.92,84.38 64.52,84.38 64.34,84.2 64.34,80.34 66.57,78.12 66.57,72.38 64.03,69.84 61.09,69.84 58.67,67.41 58.67,63.03 v1(57.77,62.13) 56.94,61.3 PR58.1
  IN3 w0.127: v1(91.59,62.66) 91.01,63.24 79.7,63.24 78.6,62.14 75.2,62.14 74.96,61.9 71.67,61.9 71.3,61.54 71.3,61.11 71.53,60.88 71.53,58.8 70.39,57.65 70.39,56.35 69.47,55.44 69.47,54.12 68.87,53.52 68.87,52.24 67.68,51.05 64.96,51.05 64.38,50.47 58.71,50.47 56.34,52.83 56.34,61.69 56.86,62.21 57.69,62.21 v1(57.77,62.13)
  BOTTOM w0.089: v1(91.59,62.66) 91.59,62.73 U22.AG41
VCCGISS_SENSE: length 90.1
  TOP w0.14: PR49.1 57.16,62.37 v1(57.16,63.55) 57.69,63.55 v1(57.94,63.8) 58.14,64 58.14,67.63 60.88,70.36 63.82,70.36 66.05,72.59 66.05,77.9 63.82,80.12 63.82,84.42 64.31,84.9 64.93,84.9 PR2.2
  IN3 w0.089: 82.33,63.75 84.58,63.75 84.61,63.78
  IN3 w0.127: 84.61,63.78 84.93,64.1 86.22,64.1 86.65,63.68 91.36,63.68 v1(92.3,62.73) ; 82.33,63.75 78.42,63.75 78.11,64.06 77.63,64.06 76.61,63.04 73.06,63.04 72.47,62.46 70.95,62.46 70.8,62.3 70.8,60.83 71.03,60.6 71.03,59.01 69.88,57.87 69.88,56.56 68.96,55.65 68.96,54.35 68.36,53.74 68.36,52.45 67.47,51.56 64.75,51.56 64.17,50.98 58.92,50.98 56.85,53.04 56.85,58.9 58.63,60.68 58.63,62.08 v1(57.16,63.55)
  BOTTOM w0.089: U22.AG39 v1(92.3,62.73)
VCCRTC_2: length 19.3
  TOP w0.508: Q28.1 158.88,3.96 v1(158.66,3.73) 158.53,3.61 R387.1
  BOTTOM w0.508: v1(158.66,3.73) 157.51,4.88 157.51,5.41 157,5.92 155.2,5.92 154.34,6.78 148.24,6.78 146.82,8.2 CN14.1
VCCRTC_3: length 2.6
  TOP w0.508: R388.2 162.85,3.61 v1(162.72,3.73) 162.08,3.73 161.68,4.14 Q28.3
VCCRTC_4: length 2.1
  TOP w0.508: R389.2 R388.1 165.26,3.61 v1(165.39,3.73)
VDD10: length 4.5
  TOP w0.203: U3.8 33.44,91.24 v1(33.69,91.49) ; v1(27.39,88.92) 27.7,89.24 U3.22 ; v1(33.74,89.25) 33.72,89.24 U3.3 ; v1(31.3,86.59) 31.24,86.65 U3.30
VDDI_DSC: length 5
  TOP w0.254: C159.2 67.04,56.05 v1(67.09,56.01)
  BOTTOM w0.079: U26.C2 64.89,55.67 65.06,55.49 65.57,55.49 65.88,55.8
  BOTTOM w0.086: 65.69,55.99 65.14,55.99
  BOTTOM w0.089: 65.14,55.99 U26.C2
  BOTTOM w0.254: 65.69,55.99 65.88,55.8 66.88,55.8 v1(67.09,56.01)
VDDREG/VDD33:
  vias: v1(24.67,83.36) v1(25.31,83.83) v1(25.31,83.2) v1(25.94,83.21) v1(25.97,83.84) v1(27.41,88.29) v1(27.46,87.65)
1P35V_CS: length 4.4
  BOTTOM w0.127: PR242.2 146.34,27.1 146.79,27.56 146.79,28.32 v1(147.23,28.75)
  BOTTOM w0.203: PU15.13 144.81,26.34 145.07,26.59 145.84,26.59 PR242.2
1P35V_FB: length 2.5
  BOTTOM w0.203: PU15.6 142.23,23.38 PR251.2
  BOTTOM w0.254: PR250.1 141.02,23.04 PR251.2
1P35V_LGATE: length 7.6
  BOTTOM w0.635: 151.96,29.75 v1(150.78,29.75) 150.06,29.75 146.34,26.03 145.93,26.03
1P35V_PGOOD: length 3.1
  BOTTOM w0.127: PU15.10 142.64,25.55 PR245.1 142.64,26.23 142.27,26.59 141.89,26.59 v1(141.38,27.1)
1P35V_PHASE: length 1
  TOP w0.508: v1(153.37,26.07) 153.83,26.53 PR85.1
  vias: v1(149,25.83)
1P35V_S3: length 5.9
  BOTTOM w0.127: PU15.7 142.16,23.78 PR248.2 141,24.04 PC223.1 140.88,23.93 140.43,23.48 139.25,23.48 138.85,23.87 PR249.1 138.72,23.79 v1(138.72,23.04)
1P35V_S5: length 7.5
  BOTTOM w0.127: v1(136.94,25.45) 138.59,25.45 138.85,25.19 PR246.1 138.85,24.68 139.03,24.5 140.44,24.5 PC221.1 141,24.82 PR248.1 142.53,24.18 PU15.8
1P35V_TON: length 6.3
  BOTTOM w0.127: PR243.2 138.85,26.96 v1(138.84,26.97)
  BOTTOM w0.203: PU15.9 142.63,24.58 142.4,24.81 142.4,25.2 142.15,25.45 139.1,25.45 138.85,25.69 PR243.2
1P35V_UGATE: length 8
  IN3 w0.635: v2(147.6,24.81) 153.95,24.81 154.67,25.53 v2(154.67,26.13)
1P35V_VDD: length 5
  BOTTOM w0.127: v1(145.88,29.39) 145.88,27.4 145.57,27.09 PR241.2
  BOTTOM w0.203: PC220.1 144.3,26.72 144.41,26.61 PU15.12
  BOTTOM w0.254: PC220.1 PR241.2
1P35V_VDDQ: length 4.3
  BOTTOM w0.127: v1(140.88,21.01) PR252.2
  BOTTOM w0.203: PR251.1 142.2,22.58 PU15.5
  BOTTOM w0.254: PR252.2 141.26,22.27 PR251.1
1P35V_VID: length 4.3
  BOTTOM w0.127: PR239.1 141.38,27.98 v1(141.38,28.37)
  BOTTOM w0.203: PR240.1 144.01,26.37 PU15.11
  BOTTOM w0.254: PR239.1 PR240.1
2ND_MBCLK: length 38.7
  TOP w0.14: v1(51.38,47.71) 49.97,47.71 49.15,46.88 47.81,46.88 46.88,47.81 40.29,47.81 39.77,47.28 39.77,47.28 39.07,46.59 v1(37.62,46.59) 36.58,45.54 35.97,45.54 35.69,45.26 34.26,45.26 34.14,45.13 28.62,45.13 R234.1 28.61,44.89 28.61,42.21 29.12,41.71 29.12,41.17 29.51,40.78 U14.115
  BOTTOM w0.14: v1(51.38,47.71) 51.84,48.16 51.84,52.4 52.58,53.14 52.58,53.36 53.16,53.94 U27.1
2ND_MBDATA: length 41.7
  TOP w0.14: U14.116 29.11,40.78 28.67,41.21 28.67,41.58 28.26,41.99 28.26,42.55 R262.1 27.27,43.09 25.94,44.42 25.94,45.01 26.46,45.53 33.8,45.53 34.25,45.97 35.1,45.97 35.61,46.48 v1(36.25,46.48) 36.48,46.48 37.67,47.67 39.53,47.67 40.06,48.2 47.05,48.2 47.97,47.27 48.53,47.27 49.41,48.16 51.75,48.16 51.9,48 51.9,47.37 v1(51.64,47.12)
  BOTTOM w0.14: U27.5 53.16,48.63 v1(51.64,47.12)
680_LDO: length 200.2
  TOP w0.127: v1(47.83,44.85) 48.1,44.59 U12.1 48.6,43.84 48.7,43.74 R254.2 C208.1 ; v1(153.7,52.25) PR71.1
  TOP w0.254: PR71.1 153.99,51.19 154.36,50.82 154.36,49.45 154.62,49.2 154.93,49.2 155.25,48.88 155.25,48.59 v1(155.33,48.51)
  IN1 w0.089: v1(153.52,38.68) 153.17,38.33 152.42,38.33 151.74,37.65 151.41,37.33 151.41,36.64 149.66,34.88 149.66,33.2 146.28,29.82 145.06,29.82 140.33,25.09 140.33,24.21 139.64,23.52 138.14,23.52 136.8,22.19 135.4,22.19 134.55,23.04 126.06,23.04 125.03,22.01 118.69,22.01 116.29,19.61 114.13,19.61 111.69,17.17 99.17,17.17 98.57,16.58 90.76,16.58 86.32,12.13 76.54,12.13 74.82,10.41 60.74,10.41 58.36,12.78 49.17,12.78 47.64,14.32 47.04,14.32 37.96,14.32 34.45,17.82 34.45,19.44 33.39,20.5 33.39,26.75 33.23,26.9 31.55,26.9 30.78,27.67 29.66,27.67 29.35,27.98 29.35,29.62 29.93,30.2 v1(29.93,30.22)
  IN2 w0.127: v1(153.52,38.68) 153.52,38.9 154.13,39.51 154.13,48.89 154.44,49.2 155.02,49.2 155.33,48.89 v1(155.33,48.51)
  IN3 w0.127: v1(47.83,44.85) 47.78,44.8 47.78,42.47 46.9,41.58 46.9,40.37 44.46,37.93 41.42,37.93 40.33,36.85 40.33,35.78 36.29,31.74 34.26,31.74 34.18,31.81 31.52,31.81 v1(29.93,30.22)
5671EN_1.24V: length 4
  BOTTOM w0.254: PU7.5 134.29,73.61 PC142.1 134.64,74.34 134.78,74.47 135.91,74.47 PR148.2
5671FB_1.24V: length 4.9
  BOTTOM w0.254: PR145.2 140.25,74.13 v1(140.42,73.96) PC143.2 139.61,73.84 138.83,73.07 PR149.1 138.44,72.55 PU7.6
5671FB_1.24V_S: length 3.3
  BOTTOM w0.127: v1(138.03,73.71) 138.58,73.71 PC143.1
  BOTTOM w0.254: PR144.2 PR145.1 139.47,74.61 138.83,73.97 PC143.1
5671LX_1.24V:
  vias: v1(133,70.92)
5671NC_1.24V: length 1.6
  BOTTOM w0.229: PC150.1 138.71,72.05 PU7.7
5671PG_1.24V: length 3.1
  BOTTOM w0.127: PR147.1 133.31,73.57 v1(132.8,74.09)
  BOTTOM w0.229: PR147.1 133.64,72.32 133.9,72.05 PU7.4
5671SVIN_1.24V: length 4.7
  BOTTOM w0.127: v1(140.11,70.03) 139.48,69.39 PR167.2
  BOTTOM w0.254: PR167.2 138.83,69.64 PC151.1 138.2,71.55 PU7.8
24780_ACDET: length 5.3
  TOP w0.178: PU2.6 144.98,8.02 PR123.2
  TOP w0.254: PR128.2 v1(146.58,5.26) 146.21,5.64 146.21,7.03 145.95,7.3 PR123.2
24780_ACDRV: length 205
  TOP w0.178: v1(144.43,5.89) 144.18,6.15 PU2.4
  TOP w0.254: PR15.2 v1(16.28,70.53) 16.28,68.69 16.42,68.55 v1(16.42,68.55)
  IN3 w0.254: v1(16.42,68.55) 16.42,68.37 15.5,67.45 15.5,26.87 16.24,26.13 16.24,22.73 16.79,22.17 16.79,16.63 17.61,15.81 17.61,13.67 16.71,12.77 16.71,10.6 16.91,10.41 16.91,8.6 16.85,8.54 16.85,7.72 17.91,6.66 58.5,6.66 59.63,7.8 64.96,7.8 66.1,6.65 120.43,6.65 121.57,7.8 124.49,7.8 127.16,10.46 132.01,10.46 137.04,5.43 137.04,4.47 138.35,3.16 143.76,3.16 144.18,3.58 144.18,5.64 v1(144.43,5.89)
24780_ACN: length 199.2
  TOP w0.178: PU2.1 142.98,8.63 142.65,8.3 142.18,8.3 PC105.2
  TOP w0.254: v1(141.64,5.43) 141.3,5.43 PC109.1 140.88,7 PC105.2
  IN3 w0.254: v1(22.97,67.64) 22.89,67.56 22.89,67.03 23.95,65.97 23.95,62.43 22.35,60.83 22.35,58.05 19.59,55.29 19.59,51.02 16.64,48.07 16.64,27.42 17.38,26.68 17.38,23.2 17.96,22.62 17.96,17.12 18.75,16.34 18.75,13.14 17.86,12.25 17.86,11.08 18.68,10.26 40.6,10.26 41.58,9.28 51.88,9.28 52.6,8.56 55.78,8.56 56.5,9.28 58.43,9.28 58.77,8.94 65.55,8.94 66.44,8.05 83.61,8.05 84.12,8.56 110.3,8.56 110.93,7.93 119.91,7.93 121.04,9.07 123.97,9.07 126.63,11.73 132.36,11.73 137.24,6.86 140.04,6.86 141.46,5.43 v1(141.64,5.43)
  BOTTOM w0.254: v1(22.97,67.64) 23.79,68.46 24.48,68.46 PR164.1
24780_ACP: length 200.7
  TOP w0.178: PC105.1 143.38,8.3 PU2.2
  TOP w0.254: v1(143.03,5.26) 143,5.26 PC110.2 142.36,5.89 PC105.1
  IN3 w0.254: v1(143.03,5.26) 142.63,5.26 142.3,4.93 141.08,4.93 139.81,6.2 137.36,6.2 132.2,11.35 126.79,11.35 124.12,8.69 121.2,8.69 120.07,7.55 110.77,7.55 110.14,8.18 84.28,8.18 83.77,7.67 66.28,7.67 65.39,8.56 58.61,8.56 58.27,8.9 56.66,8.9 55.94,8.18 52.44,8.18 51.72,8.9 41.42,8.9 40.44,9.88 18.52,9.88 17.48,10.92 17.48,12.41 18.37,13.31 18.37,16.18 17.58,16.97 17.58,22.46 17,23.04 17,26.52 16.26,27.26 16.26,48.23 19.21,51.18 19.21,55.48 21.93,58.19 21.93,61.88 22.22,62.18 22.99,62.18 23.57,62.75 23.57,65.82 22.46,66.92 22.46,67.89 v1(22.97,68.4)
  BOTTOM w0.254: PR163.1 23.52,68.95 v1(22.97,68.4)
24780_BATDRV: length 30.7
  TOP w0.127: PU2.18 v1(144.18,13.77)
  TOP w0.508: PR96.1 121.83,15.77 v1(120.99,16.61) v1(120.45,17.14)
  IN1 w0.254: v1(120.45,17.14) 121.19,16.41 121.19,14.84 123.22,12.81 133.81,12.81 135.07,14.07 143.87,14.07 v1(144.18,13.77)
24780_BATSRC: length 2.2
  TOP w0.178: PU2.17 144.58,13.44 PR94.2
24780_BM#: length 3.6
  TOP w0.178: PU2.16 144.98,13.37 145.54,13.94 146.25,13.94 v1(146.67,14.35) 146.97,14.65 PR89.1
24780_CMPIN: length 2.2
  TOP w0.178: PR101.1 147.28,12.43 147.28,12.11 146.81,11.64 PU2.13
24780_CMPOUT: length 2.6
  TOP w0.178: PR97.1 147.28,13.45 147.28,13.32 v1(146.84,12.88) 146.72,12.75 146.72,12.37 146.39,12.04 PU2.14
24780_CMSRC: length 1.6
  TOP w0.178: PR121.2 143.78,7.4 PU2.3
24780_DH: length 10.6
  IN3 w0.635: v2(133.51,15.54) 133.72,15.33 135.26,15.33 135.52,15.07 137.1,15.07 138.65,13.52 139.44,13.52 140.05,12.91 140.05,11.29 v2(141,10.34)
24780_DL: length 8.2
  IN3 w0.635: v2(136.15,16.09) 137.61,16.09 139.21,14.49 140.63,14.49 141.45,13.67 141.45,12.05 v2(141.26,11.86)
24780_ILIM: length 5.3
  TOP w0.127: PU2.21 142.98,13.15 142.51,13.62 141.91,13.62 v1(141.51,14.02) 141.26,14.27 141.26,14.9 PR88.1 PC82.2 PR87.1
24780_LX: length 14.6
  TOP w0.508: v2(132.87,16.05) v1(132.02,16.9) PR86.1
  IN3 w0.635: v2(141,9.57) 140.34,9.57 139.64,10.27 136.24,10.27 132.67,13.84 132.67,15.85 v2(132.87,16.05)
24780_SRN: length 30.8
  TOP w0.254: v1(143.42,15.16) 143.42,15.54 143.63,15.76 PR93.1 144.23,16.31 143.8,16.73 PC77.1 PC78.2
  IN1 w0.178: v1(121.19,18.85) 121.67,19.33 124.78,19.33 124.94,19.16 132.3,19.16 132.98,19.84 136.6,19.84 136.81,19.62 138.28,19.62 139.06,18.84 139.06,16.08 139.53,15.61 142.97,15.61 v1(143.42,15.16)
  BOTTOM w0.254: PR256.2 v1(121.19,18.85)
24780_SRP: length 28
  TOP w0.254: v1(141.76,15.16) 141.76,15.54 141.98,15.76 PR92.1 142.63,16.41 143.03,16.8 PC77.2 141.98,17.19 PC76.2
  IN1 w0.178: v1(141.76,15.16) 141.6,15.33 139.41,15.33 138.78,15.96 138.78,18.72 138.16,19.34 136.7,19.34 136.48,19.56 133.09,19.56 132.42,18.88 124.83,18.88 124.66,19.05 122.41,19.05 v1(122.21,18.85)
  BOTTOM w0.254: PR257.2 v1(122.21,18.85)
24780_VCC:
  vias: v1(141.13,8.56)
61087COMP: length 2.3
  BOTTOM w0.127: v1(171.1,65.58) 171.09,65.59 R494.2
  BOTTOM w0.254: R494.2 170.2,65.61 PU8.1
61087EN: length 5.8
  BOTTOM w0.127: R499.2 167.68,64.18 166.66,64.18 v1(166.53,64.31)
  BOTTOM w0.254: PU8.3 169.2,66.47 168.94,66.22 168.7,66.22 C395.2 R498.2 R499.2
61087FB: length 6
  BOTTOM w0.127: R500.1 168.19,61.78 v1(168.18,61.77)
  BOTTOM w0.254: PU8.2 169.7,66.09 R493.2 168.95,65.59 168.69,65.33 168.69,63.16 R500.1
61087FREQ: length 4.9
  BOTTOM w0.254: PU8.9 169.7,70.53 169.83,70.66 v1(171.61,70.66) R474.1 173,69.66 R478.2
61087SS: length 1.9
  BOTTOM w0.254: PU8.10 170.52,69.65 C391.2
61087SW:
  vias: v1(167.93,71.17)
+601_VCC: length 15.2
  BOTTOM w0.254: C450.2 127.15,27.1 128.3,27.1 128.95,26.45 U32.16
  BOTTOM w0.508: R563.1 v1(128.43,29.26) 127.79,29.89 125.12,29.89 124.75,29.52 124.75,28.3 125.19,27.85 C449.2 C450.2 ; R569.1 v1(134.53,29.26) ; R580.1 v1(130.97,19.61) ; v1(132.12,29.26) 132.12,29.01 R567.1 ; R578.1 v1(128.94,19.61) ; R576.1 126.91,19.62 v1(126.9,19.61) ; R564.1 v1(129.45,29.26)
  vias: v1(127.79,20.88) v1(133,21.64) v1(134.02,21.64)
+AZA_VDD:
  vias: v1(171.48,13.38) v1(175.29,22.02) v1(175.93,22.02) v1(176.69,15.16) v1(176.69,14.53)
+G_SEN_PW: length 19.3
  TOP w0.254: v1(97.82,7.54) 97.82,8.43 97.43,8.82 C323.1 96.55,10.46 96.04,10.98 U17.8 ; v1(90.96,7.54) 90.98,7.54 91.47,8.03 R374.2 ; v1(95.03,7.54) 95.02,7.54 R376.2
  IN2 w0.508: v1(87.15,7.54) 87.79,8.18 90.33,8.18 v1(90.96,7.54) 91.6,8.18 94.39,8.18 v1(95.03,7.54) 95.66,8.18 97.57,8.18 97.82,7.92 v1(97.82,7.54)
  vias: v1(88.17,8.56)
+LCDVCC_1:
  vias: v1(160.56,76.76)
+SMDDR_VREF_DQ1_M1: length 109.1
  TOP w0.305: U9.M1 140.38,51.45 138.97,50.04
  TOP w0.381: v1(144.52,31.68) 144.28,31.44 144.28,31.14 v1(144.05,30.91) 144.04,30.91 143.8,30.66 C244.1 R299.1 C243.2 140.38,31.03 U13.M1 ; 138.97,50.04 136.84,50.04 135.91,49.11 C196.2 134.79,48.51 C201.2 134.78,48.94 134.91,49.07 v1(134.91,50.68)
  IN1 w0.381: v1(150.86,37.64) 152.51,39.29 152.98,39.29 153.43,39.75 153.43,50.4 153.04,50.79 152.37,50.79 151.56,51.6 151.56,58.96 v1(151.29,59.23)
  IN2 w0.381: v1(134.91,50.68) 135.76,49.83 145.61,49.83 148.32,52.55 149.84,52.55 151.29,54 v1(151.29,59.23)
  BOTTOM w0.305: U30.M1 140.37,40.54 140.37,41.28 140.72,41.63 141.76,41.63 142.25,42.11 143.92,42.11 ; 143.8,60.12 141.51,60.12 140.38,58.99 U25.M1
  BOTTOM w0.381: 143.8,60.12 144.06,59.86 C403.2 C404.2 C405.2 R512.2 152.02,59.86 R516.2 151.71,59.23 v1(151.29,59.23) ; 143.92,42.11 146.34,42.11 146.87,41.58 C425.1 C423.2 147.34,42.69 147.86,43.22 149.11,43.22 149.44,42.88 149.44,41.48 150.86,40.06 v1(150.86,37.64) 149.45,36.23 149.45,32.73 148.48,31.76 147.06,31.76 146.46,32.37 145.03,32.37 144.52,31.86 v1(144.52,31.68)
+TPVDD_1:
  vias: v1(82.71,9.19) v1(82.84,11.35)
+VNN: length 5
  TOP w0.178: PR11.1 42.96,75.23 v1(42.7,74.98)
  BOTTOM w0.178: PL4.2 v1(42.7,74.98)
  BOTTOM w0.229: U22.AF35 94.36,63.28 v1(94.35,63.28)
  BOTTOM w0.254: v1(94.35,63.28) 94,62.93 U22.AG36 93.95,62.93 v1(93.59,63.28)
  vias: v1(72.62,56.94) v1(72.68,56.31) v1(72.68,55.68) v1(73.25,56.97) v1(73.31,56.31) v1(73.82,57.38) v1(73.85,56.74) v1(74.5,57.4) v1(88.75,62.73) v1(88.75,61.78) v1(89.46,62.73) v1(89.46,61.78) v1(98.16,63.3) v1(98.16,62.56) v1(98.16,61.11) v2(43.21,71.42) v2(43.97,71.42) v2(43.97,70.66) v2(43.97,69.9) v2(43.97,69.14) v2(43.97,68.38) v2(43.97,67.61) v2(44.74,70.66) v2(44.74,69.9) v2(44.74,69.14) v2(44.74,68.38) v2(44.74,67.61)
+VREF_CA_CPU: length 54.8
  TOP w0.381: R212.1 v1(116.78,46.44) 117.82,45.39 117.82,35.73 121.87,31.69 v1(121.87,28.88)
  IN3 w0.381: v1(95.53,18.72) 96.1,19.29 98.45,19.29 99.41,20.24 114.63,20.24 116.07,21.68 118.55,21.68 118.9,22.03 118.9,26.97 120.15,28.22 121.47,28.22 121.87,28.62 v1(121.87,28.88)
+VREF_VCGI: length 31.4
  IN1 w0.089: v1(64.29,67.7) 64.15,67.7 63.39,66.93 61.11,66.93 55.37,61.19 55,61.19 54.9,61.3 54.3,61.3 v1(53.5,60.5)
  BOTTOM w0.127: v1(64.29,67.7) 64.29,68.24 PR155.2 63.78,68.76 59.72,68.76 59.59,68.62 PR169.1 59.58,68.26 PR172.1 58.33,68.26 57.04,66.96 PU10.17 ; PR201.2 48.42,62.14 48.75,62.47 50,62.47 50.21,62.27 PC188.1 PR207.1 51.64,61.58 52.54,61.58 PR208.1 53.25,61.76 53.25,60.76 v1(53.5,60.5)
+VREF_VNN: length 28.7
  TOP w0.203: PU1.17 30.03,65.95 PR31.1 30.01,66.21 29.75,66.47 28.73,66.47 v1(28.71,66.5) 28.64,66.5 PR30.1 27.6,66.47 27.15,66.47 26.86,66.76 26.86,67.03 26.29,67.61 26.29,67.9 25.97,68.22 25.97,68.91 26.29,69.23 26.29,69.61 v1(26.45,69.77) 26.45,69.77 27.08,70.41 PR16.2
  TOP w0.254: PR66.1 PR67.1 36.13,58.88 37.35,58.88 38.01,59.54 PR65.1 39.05,60.64 39.05,61.49 38.76,61.78 PC48.1 38,61.78 v1(37.37,62.41)
  IN2 w0.203: v1(37.37,62.41) 36.81,62.96 32.07,62.96 28.71,66.33 v1(28.71,66.5)
+VREFDQ_SB_M3: length 2.8
  BOTTOM w0.381: R516.1 151.5,57.83 R519.1 C410.1
ACCEL_INT2: length 55.8
  TOP w0.127: U17.9 v1(97.06,10.08) 98.46,8.69 v1(98.46,7.54)
  BOTTOM w0.127: R606.2 56.1,15.93 55.85,16.19 55.85,16.87 55.98,17 58.52,17 58.56,16.96 71.9,16.96 72.55,16.31 72.55,15.14 73.62,14.07 74.23,14.07 75.41,12.89 75.41,9.64 76.3,8.74 88.98,8.74 89.73,7.99 98.01,7.99 v1(98.46,7.54)
ACCEL_INTA: length 7.7
  TOP w0.127: 100.49,8.69 100.1,9.07 v1(100.1,11.23) C304.2 99.97,13.26 U17.11
ACIN: length 161
  TOP w0.127: PR122.2 145.07,6.14 v1(145.07,5.87) 145.07,5.65 PR127.2 PR126.1
  TOP w0.14: U14.72 37.47,28.78 34.23,32.02 31.98,32.02 31.6,31.64 28.31,31.64 27.95,31.27 24.79,31.27 v1(24.72,31.34)
  IN1 w0.089: v1(145.07,5.87) 145.07,6.09 144.87,6.29 136.69,6.29 132.58,10.4 124.63,10.4 123.98,9.75 121.21,9.75 119.05,7.59 110.48,7.59 109.93,8.13 83.85,8.13 82.82,7.11 65.72,7.11 65.13,7.7 59.62,7.7 58.32,9 40.75,9 40.35,9.4 32.26,9.4 31.4,10.26 v1(31.4,11.53) 31.4,12.71 25.93,18.18 25.93,26.4 25.77,26.57 25.77,29.31 24.93,30.15 24.63,30.15 24.4,30.39 24.4,31.02 v1(24.72,31.34)
ACZ_SDIN: length 6.5
  TOP w0.14: U16.8 180.08,13.94 179.98,13.84 179.98,11.22 R365.1 179.73,10.73 179.99,10.46 179.99,9.4 v1(180.25,9.14)
ADOGND: length 28.6
  TOP w0.203: C284.1 175.37,19.79 U16.38 ; C270.2 183.05,22.02 182.1,22.02 181.68,21.6 U16.25
  TOP w0.254: D16.2 v1(180.63,37.13)
  TOP w0.381: R227.1 169.7,45.78 v1(169.7,45.13) ; v1(170.16,36.35) 169.63,36.88 R283.1 ; v1(184.18,14.27) 184.11,14.2 R347.1 ; v1(182.53,23.29) 182.03,22.79 R320.1 ; v1(185.45,15.92) 185.95,16.42 C294.1 ; R316.1 v1(177.84,25.95) ; R313.1 v1(174.4,26.85) ; C269.2 172.89,22.41 173.16,22.68 173.16,24.03 172.75,24.43 R317.1 173.26,25.19 v1(173.26,25.45) ; C287.2 v1(185.45,19.49)
  TOP w0.508: C247.1 v1(176.05,27.1) ; C227.1 171.47,36.61 v1(170.62,35.76) ; C284.1 174.78,20.62 v1(174.4,21) 174.4,21.37 C272.2 ; C263.2 v1(182.03,24.56) ; C183.1 170.71,52.24 v1(170.21,51.74) 170.71,51.24 C188.1 ; C265.1 v1(180.12,24.69) ; C248.2 v1(177.32,26.85) ; v1(184.44,22.78) C270.2 ; v1(171.36,48.06) 171.47,48.06 C195.1 ; v1(175.28,26.47) 175.68,26.47 R315.2 ; C264.2 v1(184.44,23.93) ; R293.1 v1(176.18,30.53) ; C190.1 v1(175.17,50.6)
  vias: v1(186.34,24.05) v2(175.04,42.19) v2(175.09,46.15) v2(175.11,44.6) v2(175.14,39.65) v2(186.98,33.07) v2(187.13,30.5) v2(187.13,27.96) v2(187.13,25.42) v2(187.13,22.88)
ALERT#: length 1.3
  BOTTOM w0.127: U27.3 55.06,56.47 TP55.1
ALERT#_VCGI: length 2.4
  BOTTOM w0.127: PU10.5 51.73,66.96 51.13,67.56 v1(51.01,67.56) 50.51,67.56 PR171.1
ALERT#_VNN: length 2.4
  TOP w0.203: v1(36.87,66.05) 36.86,66.05 36.86,66.04 36.77,65.95 PU1.5
  BOTTOM w0.203: v1(36.87,66.05) 36.87,65.83 37.5,65.2 PR186.1
AMP_MUTE#: length 206.9
  TOP w0.127: U14.109 31.91,40.87 32.04,40.99 32.04,42.04 32.15,42.15 32.15,43.38 32.42,43.64 32.42,44.12 32.67,44.37 34.44,44.37 34.72,44.65 35.44,44.65 35.82,44.27 36.83,44.27 37.37,44.8 38.66,44.8 v1(39.72,45.87) 39.94,46.09 42.55,46.09 42.83,46.37 44.44,46.37 44.94,46.86 45.99,46.86 46.75,46.1 50.94,46.1 52.12,44.92 v1(52.12,44.37) 52.12,43.1 v1(52.13,43.1) ; v1(166.38,20.75) 166.75,20.75 D26.1
  IN3 w0.127: v1(166.38,20.75) 166.28,20.75 165.58,20.05 165.58,19.67 165.37,19.47 159.35,19.47 159.14,19.68 159.14,29.6 158.93,29.81 157.63,29.81 156.84,30.59 151.56,30.59 150.29,29.32 147.8,29.32 147.66,29.19 144.54,29.19 142.08,26.73 142.08,24.31 139.6,21.83 137.52,21.83 136.51,20.83 126.32,20.83 125.82,20.33 124.32,20.33 121.65,17.66 121.65,13.66 119.92,11.92 111.66,11.92 110.9,11.16 89.2,11.16 87.73,12.63 74.98,12.63 73.09,10.75 59.39,10.75 59.03,11.1 55.75,11.1 53.65,13.19 49.56,13.19 46.24,16.51 46.24,19.6 45.1,20.74 45.1,21.91 44,23.02 44,24.75 45.07,25.82 45.07,32.63 46.64,34.2 46.64,36.52 48.48,38.36 48.97,38.36 52.13,41.51 v1(52.13,43.1)
AZ_CODEC_BITCLK: length 165.1
  TOP w0.14: R364.2 178.09,9.95 177.82,10.22 174.52,10.22 v1(174.17,10.56)
  IN1 w0.089: v1(174.17,10.56) 174.15,10.59 173.92,10.36 172.78,10.36 172.49,10.07 172.49,8.8 171.04,7.35 169.95,7.35 169.72,7.58 159.16,7.58 157.66,9.09 157.66,9.81 158.63,10.78 158.63,14.14 159.94,15.45 159.94,19.35 159.47,19.82 159.47,28.49 159.79,28.81 161.89,28.81 163.68,30.6 163.68,44.34 164.16,44.82 164.16,48.63 166.47,50.94 166.47,51.52 168.58,53.62 168.58,54.28 168.58,64.75 168.57,64.76 168.57,65.73 168.47,65.84 168.47,65.89 167.04,67.33 167.04,72.02 167.04,72.02 167.04,72.5 165.7,73.84 162.33,73.84 161.85,74.32 157.47,74.32 153.4,78.38 153.09,78.38 153.09,78.38 150.91,78.38 147.61,81.68 144.05,81.68 142.96,82.77 127.24,82.77 126.59,83.42 117.42,83.42 116.92,83.92 111.34,83.92 110.43,83.02 107.69,83.02 107.37,82.71 104.22,82.71 v1(103.3,81.79)
  BOTTOM w0.14: C353.2 103.3,81.97 v1(103.3,81.79) 103.3,81.54 102.84,81.08 R425.2
AZ_CODEC_RST#: length 180.6
  TOP w0.14: Q13.1 164.17,25.01 v1(164.17,20.37) 164.17,20.05 163.93,19.8 159.89,19.8 v1(159.07,18.98) ; U16.11 181.28,14.38 181.67,13.99 v1(181.67,13.94)
  IN1 w0.089: v1(181.67,13.94) 181.67,13.48 178,9.82 175.38,9.82 171.58,6.02 162.05,6.02 161.18,6.89 158.88,6.89 156.97,8.8 156.97,10.09 157.94,11.06 157.94,14.42 159.26,15.74 159.26,18.8 v1(159.07,18.98) 158.78,19.28 158.78,28.77 159.5,29.49 161.6,29.49 162.99,30.88 162.99,44.62 163.47,45.11 163.47,48.92 165.79,51.23 165.79,51.8 167.89,53.91 167.89,64.47 167.89,64.48 167.89,65.45 166.32,67.02 166.32,71.75 166.32,72.24 165.41,73.15 162.05,73.15 161.57,73.63 157.18,73.63 153.12,77.7 152.74,77.7 152.71,77.67 150.02,77.67 147.48,80.21 143.54,80.21 141.66,82.08 132.34,82.08 131.78,81.52 126.99,81.52 126.48,82.02 126.48,82.55 126.31,82.73 117.23,82.73 116.57,82.07 114.74,82.07 113.57,83.23 111.67,83.23 110.73,82.29 108.06,82.29 107.2,81.44 105.05,81.44 v1(104.78,81.71)
  BOTTOM w0.14: R427.1 104.81,81.68 v1(104.78,81.71)
AZ_CODEC_SDIN0: length 176.5
  TOP w0.14: v1(173.26,10.84) 174.28,9.83 177.6,9.83 177.89,9.53 179.07,9.53 R365.2
  IN1 w0.089: v1(107.86,84.66) 108.63,85.43 116.53,85.43 116.8,85.16 123.02,85.16 123.31,84.87 126.47,84.87 127.63,83.71 143.35,83.71 144.44,82.62 148.07,82.62 150.95,79.74 151.3,79.74 151.31,79.73 153.48,79.73 157.35,75.86 159,75.86 159.6,75.26 162.24,75.26 162.72,74.78 166.09,74.78 167.98,72.89 167.98,72.5 167.98,71.63 167.98,71.63 167.98,67.71 170.12,65.57 170.12,62.04 169.76,61.68 169.76,56.38 170.52,55.62 170.52,54.9 166.94,51.32 166.94,51 166.94,50.75 166.5,50.3 166.5,42.46 164.15,40.11 164.15,31.71 166.29,29.56 166.29,22.24 164.57,20.52 164.57,19.04 160.67,15.14 160.3,15.14 159.73,14.57 159.1,13.95 159.1,10.58 158.13,9.61 158.13,9.28 159.36,8.05 170.4,8.05 172.02,9.67 172.02,10.27 172.59,10.84 v1(173.26,10.84)
  BOTTOM w0.089: 103.47,78.77 103.47,78.05 101.54,76.12 101.25,76.12 100.87,75.74 100.87,75.23 100.94,75.17 U22.B21
  BOTTOM w0.14: v1(107.86,84.66) 107.24,85.27 R408.1 106.67,85.27 105.32,83.92 105.32,82.97 R415.2 104.36,82.01 104.36,79.66 103.47,78.77
AZ_CODEC_SDOUT: length 167.3
  TOP w0.14: U16.5 178.88,14.08 178.54,13.74 v1(178.54,13.18)
  IN1 w0.089: v1(178.54,13.18) 178.43,13.07 178.43,11.41 177.3,10.29 175.19,10.29 171.78,6.88 169.75,6.88 169.53,7.11 158.97,7.11 157.19,8.89 157.19,10 158.16,10.97 158.16,14.33 159.47,15.65 159.47,19.15 159,19.63 159,28.68 159.6,29.28 161.69,29.28 163.21,30.79 163.21,44.53 163.69,45.02 163.69,48.83 166,51.14 166,51.71 168.11,53.82 168.11,64.56 168.1,64.57 168.1,65.54 168,65.64 168,65.7 166.57,67.13 166.57,72.22 166.57,72.3 165.5,73.37 162.14,73.37 161.66,73.85 157.27,73.85 153.21,77.91 152.65,77.91 152.62,77.88 150.11,77.88 147.57,80.42 143.63,80.42 141.75,82.3 132.25,82.3 131.69,81.74 127.08,81.74 126.7,82.11 126.7,82.64 126.39,82.95 117.23,82.95 116.72,83.45 111.53,83.45 110.63,82.55 107.88,82.55 107.57,82.24 104.43,82.24 v1(103.93,81.74)
  BOTTOM w0.14: v1(103.93,81.74) 103.93,81.22 R426.2
AZ_CODEC_SYNC: length 175.6
  TOP w0.14: v1(181.01,13.98) 180.88,14.1 U16.10
  IN1 w0.089: v1(102.27,84.89) 103.97,83.18 106.84,83.18 107.25,83.59 107.25,85.17 107.98,85.9 116.73,85.9 117,85.63 122.33,85.63 122.48,85.77 125.87,85.77 127.72,83.92 143.44,83.92 144.53,82.83 148.16,82.83 151.04,79.96 152.97,79.96 152.98,79.94 153.57,79.94 157.44,76.07 159.09,76.07 159.69,75.47 162.33,75.47 162.81,74.99 166.18,74.99 168.19,72.98 168.19,72.8 168.19,72.41 168.19,72.41 168.19,71.54 168.19,70.65 168.87,69.98 170.09,69.98 170.35,69.71 170.35,61.96 169.98,61.59 169.98,56.47 170.73,55.71 170.73,54.81 167.16,51.23 167.16,50.66 166.71,50.21 166.71,42.37 164.36,40.02 164.36,31.8 166.51,29.65 166.51,22.15 164.78,20.43 164.78,18.95 160.76,14.93 160.39,14.93 159.32,13.86 159.32,9.9 160.95,8.27 169.35,8.27 172.96,11.88 174.26,11.88 174.89,11.24 174.95,11.24 175.44,10.76 177.11,10.76 177.96,11.61 177.96,13.51 178.43,13.98 v1(181.01,13.98)
  BOTTOM w0.14: R414.2 102.78,84.38 v1(102.27,84.89)
BAT-V: length 3
  BOTTOM w0.127: PR256.1 121.19,17.11 121.09,17.02 121.09,15.3 120.82,15.02 PR259.2
  vias: v1(90.23,12.14) v1(90.55,14.07) v1(90.55,13.38) v1(90.58,15.92) v1(90.61,12.72) v1(91.14,13.6) v1(91.4,14.25) v1(91.77,13.69) v1(118.14,13.89) v1(118.78,13.89) v1(118.78,13.26) v1(119.41,13.89) v1(119.41,13.26)
BATLED0#: length 126.7
  TOP w0.127: v1(71.79,96.57) 72.04,96.32 72.04,94.44 72.3,94.18 R12.1 73.35,94.16 74.48,93.04 v1(76.23,93.04) 77.29,93.04 R15.1 ; U14.29 23.99,27.18 v1(25.18,28.37)
  IN1 w0.089: v1(71.79,96.57) 71.2,95.98 71.2,95.43 69.1,93.33 68.42,93.33 63.03,87.95 58.07,87.95 56.28,86.16 56.04,86.16 55.21,85.33 54.02,85.33 47.88,79.19 21.43,79.19 15.51,73.27 15.51,49.99 23.32,42.18 23.32,30.42 24.31,29.42 24.31,29.11 24.59,28.83 24.72,28.83 v1(25.18,28.37)
BATLED1#: length 118.2
  TOP w0.127: v1(71.6,95.78) 71.28,96.1 71.28,96.96 R5.1 71.03,98.2 R3.1 ; v1(24.8,29.26) 24.35,28.81 23.63,28.81 23.6,28.78 U14.25
  IN1 w0.089: v1(24.8,29.26) 24.5,29.56 24.44,29.56 23.51,30.49 23.51,42.26 15.7,50.07 15.7,73.2 21.49,78.99 47.95,78.99 54.1,85.14 55.66,85.14 v1(56.17,85.65) 57.47,86.95 57.47,87.08 58.15,87.76 63.11,87.76 68.5,93.14 69.25,93.14 71.6,95.49 v1(71.6,95.78)
BEEP_1: length 3.7
  TOP w0.14: R363.1 184.43,10.73 R361.2 183.04,11.36 C316.2 C307.2
BI#: length 37.3
  BOTTOM w0.127: SW2.2 SW2.1 123.15,24 117.05,17.9 97.82,17.9 97.63,17.71 97.63,16.69 97.25,16.31 97.06,16.31 96.31,15.55 PR260.1 v1(95.35,14.08) PJ16.6
BI_GATE: length 19.9
  TOP w0.127: v1(64.49,14.15) 64.49,14.15 v1(64.49,13.38) 64.49,12.45 C313.1 ; Q24.2 60.23,8.18 60.48,8.43 62.77,8.43 63.28,8.94 64.04,8.94 64.29,9.19 Q23.5 64.29,10.59 63.85,11.03 63.85,11.81 C313.1 ; R356.1 C313.1
  BOTTOM w0.127: v1(64.49,14.15) 65.04,13.6 SW3.4 SW3.3
BITCLK: length 5.3
  TOP w0.14: R364.1 177.89,11.17 177.89,12.3 178.07,12.48 C310.2 178.7,12.48 179,12.78 179,13.61 179.28,13.9 U16.6
BL#: length 11.6
  TOP w0.127: 158.64,72.3 158.59,72.3 158.47,72.41 158.47,72.87 158.54,72.95 Q7.2 ; 158.64,72.3 Q7.3 ; 158.64,72.3 158.27,71.93 158.27,70.52 155.86,68.1 155.55,68.1 154.93,67.48 154.93,66.56 v1(154.21,65.84) 154.21,65.24 R126.1
BL_ENABLE: length 2.8
  BOTTOM w0.127: R450.1 165.3,78.25 v1(165.3,78.46) 164.87,78.89 164.85,78.89 164.48,79.25 CN5.15
BL_ON: length 22.8
  TOP w0.127: v1(164.62,75.74) 164.12,75.23 164.12,74.59 R85.1 164.14,73.6 Q7.6 160.43,73.6 159.49,74.53 Q5.3 159.47,75.56 156.78,75.56 156.57,75.36 156.57,74.39 156.78,74.19 157.49,74.19 157.74,73.94 v1(157.74,73.2) 157.74,72.54 157.83,72.45 157.83,70.51 156.44,69.11 155.78,69.11 D5.2
  BOTTOM w0.127: R450.2 165.5,76.88 165.06,76.43 165.06,76.17 v1(164.62,75.74)
BL_PWM_DIM: length 3.5
  BOTTOM w0.14: R451.1 166.91,78.13 v1(166.58,78.46) 165.94,78.46 165.36,79.04 165.24,79.04 164.98,79.3 CN5.14
BOARD_ID0: length 21.1
  BOTTOM w0.089: 84.06,63.26 84.8,63.26 84.87,63.19 85.51,63.19 85.71,63.38 86.06,63.38 86.07,63.39 86.19,63.47 86.37,63.47 86.48,63.39 86.67,63.2 U22.AG53
  BOTTOM w0.14: 84.06,63.26 83.56,63.26 82.73,62.43 79.2,62.43 78.21,61.43 77.71,61.43 77.46,61.19 77.46,60.96 76.99,60.5 76.34,60.5 76.1,60.74 71.81,60.74 R504.2 R501.1 70.65,62.91 69.12,62.91 v1(68.99,63.04)
BOARD_ID1: length 14.1
  TOP w0.127: v1(77.96,61.01) 77.5,61.01 76.99,60.5 76.23,60.5 75.86,60.13 R159.2 75.33,60.65 74.23,60.65 73.95,60.37 R157.1
  BOTTOM w0.089: U22.AG54 85.78,63.2 85.59,63.01 84.74,63.01
  BOTTOM w0.114: 84.74,63.01 84.72,63.03 83.86,63.03
  BOTTOM w0.14: 83.86,63.03 83.03,62.2 79.29,62.2 78.11,61.01 v1(77.96,61.01)
BOARD_ID2: length 14.3
  TOP w0.127: v1(76.69,61.19) 76.49,61.39 R152.1 75.35,60.88 74.34,60.88 R151.2
  BOTTOM w0.089: 84.04,63.8 84.46,63.8 84.89,64.24 85.68,64.24 85.81,64.1 U22.AE54
  BOTTOM w0.14: v1(76.69,61.19) 76.75,61.19 77.45,61.89 78.02,61.89 79.01,62.88 81.84,62.88 82.76,63.8 84.04,63.8
BOARD_ID3: length 15.4
  BOTTOM w0.089: v1(82.48,62.91) 83.05,63.49 84.38,63.49 84.95,64.06 85.6,64.06 85.74,63.92 86.05,63.92 86.18,63.83 86.37,63.83 86.48,63.91 86.67,64.1 U22.AE53
  BOTTOM w0.14: v1(82.48,62.91) 82.22,62.65 79.1,62.65 78.11,61.66 77.55,61.66 77.23,61.35 77.23,61.06 76.92,60.76 76.5,60.76 R506.1 75.43,60.96 74.25,60.96 R505.2
BOARD_ID4: length 14.2
  BOTTOM w0.089: U22.AD55 85.9,64.62 84.67,64.62 84.36,64.31 82.48,64.31
  BOTTOM w0.14: 82.48,64.31 81.53,63.36 78.84,63.36 77.83,62.35 77.26,62.35 77.15,62.23 76.03,62.23 R503.1 75.22,63.04 v1(74.2,63.04) 73.7,63.04 R502.2
BOARD_ID5: length 20.1
  TOP w0.127: v1(71.79,61.39) R150.2 70.72,60.95 69.56,60.95 v1(69.12,61.39) R149.1
  BOTTOM w0.089: U22.AD53 86.34,64.39 86.21,64.39 86.05,64.28 85.89,64.28 85.87,64.3 85.86,64.3 85.73,64.43 84.85,64.43 84.47,64.06 83.95,64.06
  BOTTOM w0.14: v1(71.79,61.39) 72.38,61.98 77.22,61.98 77.36,62.12 77.92,62.12 78.91,63.11 81.69,63.11 82.63,64.06 83.95,64.06
BOARD_ID6: length 14.8
  TOP w0.127: v1(77.38,63.09) 76.54,63.09 R140.1 75.41,62.85 74.27,62.85 v1(73.82,62.41) R139.2
  BOTTOM w0.089: 82.28,64.82 84.16,64.82 84.35,65.01 86.28,65.01 U22.AC54
  BOTTOM w0.14: v1(77.38,63.09) 77.92,63.09 78.65,63.81 81.27,63.81 82.28,64.82
BOARD_ID7: length 19.7
  TOP w0.127: v1(76.87,62.66) 76.11,61.9 70.91,61.9 70.4,62.41 R138.2 70.38,62.4 69.94,61.96 69.57,61.96 69.13,62.4 R137.1
  BOTTOM w0.089: 84.31,64.57 84.56,64.81 86.07,64.81 86.21,64.72 86.34,64.72 86.48,64.82 86.67,65 U22.AC53
  BOTTOM w0.14: v1(76.87,62.66) 77.82,62.66 78.74,63.58 81.4,63.58 82.38,64.57 84.31,64.57
BOARD_ID8: length 13.9
  TOP w0.127: v1(77.79,63.56) 77.78,63.55 R131.2 75.86,63.42 75.55,63.11 74.27,63.11 R130.1
  BOTTOM w0.089: U22.AB53 86.43,65.35 86.15,65.25 86.05,65.18 84.19,65.18
  BOTTOM w0.14: v1(77.79,63.56) 78.27,64.04 81.17,64.04 82.18,65.05 84.06,65.05 84.19,65.18
BOOT_VCGI: length 1
  TOP w0.508: PC26.1 52.01,68.79 v2(51.98,68.76)
BT_EN: length 7.7
  TOP w0.127: v1(36.1,32.18) 36.61,32.18 37.21,32.78 37.62,32.78
  TOP w0.14: 37.62,32.78 U14.82
  BOTTOM w0.14: v1(36.1,32.18) 36.05,32.13 33.04,32.13 32.8,31.88 R561.1
BT_EN_R: length 3.6
  BOTTOM w0.127: R561.2 33.17,29.01 v1(34.07,29.01) 34.2,29.01 34.65,28.55 34.65,27.93
  BOTTOM w0.14: CN10.54 34.65,27.93
BVCCRTC_EXTPAD: length 3.4
  TOP w0.127: v1(99.65,71.47) 98.94,72.19 97.74,72.19 C82.1
  BOTTOM w0.089: v1(99.65,71.47) 100.01,71.12 U22.J23
CARD_3V3:
  vias: v1(168.88,34.01) v1(169.17,33.45) v1(169.96,22.27) v1(169.96,21.64) v1(170.09,20.88)
CCD_PWR: length 1.2
  TOP w0.381: v1(168.56,76.63) 168.56,76.81 168.09,77.28 R71.2
  vias: v1(167.67,80.95) v1(168.31,80.95)
CHA_SA0: length 4.7
  TOP w0.127: R318.1 112.88,22.06 v1(112.88,21.64) ; v1(113.52,21.77) 113.39,21.64 v1(112.88,21.64) ; v1(112.88,21.64) 113.32,21.21 R323.2
  BOTTOM w0.102: JDIM1.256 113.03,21.27 v1(113.52,21.77)
CHA_SA1: length 4.1
  TOP w0.127: R324.2 114.41,20.84 v1(114.41,21.77) 114.41,21.83 113.72,22.52 R319.1
  BOTTOM w0.102: JDIM1.260 114.03,21.38 v1(114.41,21.77)
CHA_SA2: length 5
  TOP w0.127: R334.1 R333.2 v1(91.88,20.38) 91.53,20.38 v1(90.53,21.39)
  BOTTOM w0.102: JDIM1.166 v1(90.53,21.39)
CLK_24M_DEBUG: length 101.8
  IN1 w0.089: v1(92.06,81.99) 92.06,82.5 89.97,84.59 86.04,84.59 81.45,89.18 72.44,89.18 69.14,85.88 69.14,85.07 69.73,84.48 69.73,80.61 67.68,78.56 67.68,72.14 64.68,69.14 64.04,69.14 63.42,68.52 59.77,68.52 55.84,64.59 54.79,64.59 52.89,62.68 46.02,62.68 44,60.66 44,59.71 45.02,58.7 45.02,55.58 43.78,54.35 41.67,54.35 41.14,54.88 39.21,54.88 38.75,54.42 38.75,50.67 36.14,48.07 v1(36.14,45.07)
  BOTTOM w0.089: R421.1 92.23,81.51 92.56,81.84 92.56,82.26 C351.1 92.09,82.44 92.09,82.02 v1(92.06,81.99)
  BOTTOM w0.14: v1(36.14,45.07) 36.14,44.54 37.32,43.36 38.77,43.36 38.89,43.24 R545.2 R544.2
CLK_24M_DEBUG_C: length 34.1
  BOTTOM w0.14: CN10.71 38.9,21.49 39.95,22.54 41.57,22.54 42.23,23.2 42.23,29.23 40.95,30.51 40.95,33.94 40.42,34.47 v1(40.42,35.36) 40.42,35.99 40.95,36.52 40.95,38.03 42.14,39.22 42.14,39.76 43.16,40.78 43.16,41.58 42.19,42.55 42.19,42.75 42.64,43.19 42.64,43.37 42.42,43.59 42.24,43.59 41.8,43.14 41.6,43.14 41.4,43.34 41.4,43.54 41.81,43.94 41.81,44.12 41.59,44.34 41.42,44.34 41.01,43.93 40.81,43.93 39.6,45.14 R544.1
CLK_PCI_EC: length 138
  TOP w0.14: R289.2 20.61,33.18 21.02,33.58 U14.13 23.56,33.58 24.29,34.32 v1(24.75,34.32)
  IN1 w0.089: v1(48.44,50.37) 49.49,50.37 52.51,53.39 53.02,53.39 55.91,56.28 56.07,56.44 56.07,59.59 62.57,66.08 64.18,66.08 69.27,71.17 69.27,78.01 70.57,79.31 76.06,79.31 77.58,80.84 77.58,83.3 76.21,84.67 76.21,87.16 76.72,87.67 80.78,87.67 82.68,85.76 82.68,84.5 85.3,81.88 87.07,81.88 88.9,80.06 92.62,80.06 v1(93,79.68)
  IN3 w0.127: v1(24.75,34.32) 25.17,33.89 25.17,33.66 25.26,33.57 25.55,33.57 25.68,33.69 25.68,35.04 25.83,35.19 26.04,35.19 26.19,35.04 26.19,33.69 26.32,33.57 26.57,33.57 26.7,33.69 26.7,35.05 26.85,35.2 27.06,35.2 27.2,35.05 27.2,33.69 27.33,33.57 27.59,33.57 27.71,33.69 27.71,35.11 27.83,35.22 28.08,35.22 28.22,35.08 28.22,33.69 28.35,33.57 28.6,33.57 28.73,33.69 28.73,35.16 28.86,35.29 29.11,35.29 29.24,35.16 29.24,33.69 29.36,33.57 29.62,33.57 29.74,33.69 29.74,35.21 29.87,35.33 30.13,35.33 30.25,35.21 30.25,33.69 30.38,33.57 30.63,33.57 30.76,33.69 30.76,35.26 30.87,35.37 31.12,35.37 31.27,35.22 31.27,33.69 31.4,33.57 31.65,33.57 31.78,33.69 31.78,35.22 31.9,35.35 32.16,35.35 32.28,35.22 32.28,33.69 32.41,33.57 32.96,33.57 38.8,39.41 44.45,39.41 45.94,40.9 45.94,47.86 v1(48.44,50.37)
  BOTTOM w0.089: R441.1 93.5,79.18 v1(93,79.68)
CLK_PCIE_LANN: length 131.8
  TOP w0.14: U3.16 29.24,92.59 29.16,92.67 28.34,92.67 28.22,92.55 28.22,92.36 v1(28.48,92.1)
  IN3 w0.127: v1(108.27,68.96) 108.05,68.96 107.91,69.1 107.91,69.38 107.98,69.45 108.59,69.45 110.08,70.94 111.2,70.94 111.72,71.46 114.71,71.46 115.62,72.38 116.2,72.38 116.44,72.62 116.44,74.01 114.52,75.93 114.52,78.88 114.87,79.23 115.79,80.15 115.79,81.91 116.48,82.6 116.48,84.39 114.71,86.16 114.46,86.16 112.1,88.52 111.68,88.52 108.39,91.81 98.63,91.81 97.74,92.7 94.31,92.7 93.71,93.3 71.71,93.3 69.3,90.89 63.99,90.89 63.18,90.08 59.99,90.08 59.46,89.55 53.32,89.55 47.52,83.74 36.73,83.74 35.67,84.8 34.56,84.8 34.18,85.17 34.18,92.69 34.03,92.85 33.15,92.85 32.98,92.68 28.38,92.68 28.28,92.57 28.28,92.3 v1(28.48,92.1)
  BOTTOM w0.089: v1(108.27,68.96) 108.05,68.96 107.88,68.79 U22.R5
CLK_PCIE_LANP: length 131.8
  TOP w0.14: v1(28.48,93.12) 28.66,92.94 29.27,92.94 29.64,92.57 U3.15
  IN3 w0.127: v1(107.52,68.95) 107.68,68.95 108.1,68.54 108.44,68.54 108.69,68.79 108.69,69.19 110.19,70.69 111.31,70.69 111.83,71.21 114.81,71.21 115.73,72.12 116.3,72.12 116.69,72.52 116.69,74.12 114.78,76.04 114.78,78.78 115.12,79.12 115.12,79.12 116.05,80.05 116.05,81.8 116.74,82.49 116.74,84.49 114.82,86.41 114.56,86.41 112.2,88.77 111.78,88.77 108.49,92.06 98.74,92.06 97.85,92.95 94.41,92.95 93.81,93.55 71.6,93.55 69.19,91.15 63.89,91.15 63.07,90.33 59.89,90.33 59.36,89.8 53.22,89.8 47.41,84 36.83,84 35.78,85.05 34.66,85.05 34.44,85.28 34.44,92.8 34.13,93.1 33.05,93.1 32.88,92.93 28.67,92.93 v1(28.48,93.12)
  BOTTOM w0.089: U22.R7 107.17,68.49 v1(107.52,68.95)
CLK_PCIE_WLAN_REQ#_R: length 15.9
  BOTTOM w0.127: CN10.53 34.4,18.61 36.1,16.91 R601.2 36.73,16.82 v1(37.05,16.5) 37.62,15.92 Q38.1 38.39,15.42 38.83,14.97 38.83,13.81 39.06,13.59 40.35,13.59 R616.2 40.93,15.29 41.18,15.54 42.65,15.54 42.85,15.35 U33.4
CLK_PCIE_WLANN: length 185.1
  IN3 w0.089: 106.05,74.75 106.04,74.74 106.04,74.68 105.19,73.83 105.19,70.66 105.59,70.26 105.95,70.26 106.1,70.11 v1(106.1,69.87)
  IN3 w0.127: 106.05,74.75 106.46,75.16 106.46,75.72 107.01,76.27 108.44,76.27 109.3,77.14 109.3,80.27 108.58,81 107.85,81 107.45,81.4 107.45,84.02 105.99,85.48 90.42,85.48 89.99,85.05 86.29,85.05 85.08,86.26 77.75,86.26 75.95,88.06 73.44,88.06 71.34,85.96 69.28,85.96 68.77,85.46 66.08,85.46 64.5,83.87 55.56,83.87 52.01,80.33 51.07,80.33 49.56,78.81 37.08,78.81 36.11,77.85 30.36,77.85 29.33,76.82 29.33,70.47 29.62,70.18 29.62,66.42 27.36,64.16 27.36,61.01 25.76,59.41 25.76,56.43 23.63,54.3 23.63,47.98 20.35,44.71 20.35,38.51 22.13,36.73 22.13,30.83 23.39,29.57 23.39,27.91 24.2,27.1 25.54,27.1 26.58,26.06 26.58,21.89 29.36,19.11 32.75,19.11 34.72,17.14 34.72,11.8 v1(34.95,11.57)
  BOTTOM w0.089: U22.N10 105.37,69.77 105.37,69.94 105.47,70.05 105.93,70.05 v1(106.1,69.87)
  BOTTOM w0.14: v1(34.95,11.57) 34.79,11.57 34.58,11.78 34.58,13.11 34.72,13.25 R600.2
CLK_PCIE_WLANN_NGFF: length 6.7
  BOTTOM w0.14: R600.1 34.58,14.4 34.58,15.75 v1(35.01,16.18) 34.48,16.71 34.48,17.04 33.26,18.27 33.26,18.51 33.4,18.65 CN10.49
CLK_PCIE_WLANP: length 185.1
  IN3 w0.089: v1(106.81,69.87) 106.24,70.44 105.66,70.44 105.37,70.73 105.37,73.76 106.16,74.56 106.22,74.56 106.23,74.57
  IN3 w0.127: 106.23,74.57 106.71,75.05 106.71,75.61 107.12,76.02 108.54,76.02 109.56,77.03 109.56,80.38 109.41,80.53 108.68,81.25 107.96,81.25 107.7,81.51 107.7,84.13 106.09,85.74 90.31,85.74 89.88,85.3 86.39,85.3 85.19,86.51 77.86,86.51 76.05,88.31 73.33,88.31 71.24,86.22 69.18,86.22 68.67,85.71 65.98,85.71 64.39,84.12 55.45,84.12 51.91,80.58 50.97,80.58 49.46,79.07 36.97,79.07 36,78.1 30.25,78.1 29.08,76.93 29.08,70.37 29.37,70.07 29.37,66.53 27.11,64.27 27.11,61.11 25.51,59.51 25.51,56.54 23.37,54.41 23.37,48.09 20.1,44.81 20.1,38.4 21.88,36.63 21.88,30.73 23.13,29.47 23.13,27.8 24.09,26.85 25.43,26.85 26.32,25.96 26.32,21.79 29.26,18.85 32.64,18.85 34.46,17.03 34.46,11.85 v1(34.18,11.57)
  BOTTOM w0.089: U22.N8 106.46,69.51 v1(106.81,69.87)
  BOTTOM w0.14: R599.2 34.32,12.87 34.32,11.7 v1(34.18,11.57)
CLK_PCIE_WLANP_NGFF: length 6.7
  BOTTOM w0.14: CN10.47 32.9,18.65 32.99,18.56 32.99,18.16 34.21,16.93 34.21,16.65 v1(33.74,16.18) 34.32,15.6 34.32,14.4 R599.1
CLK_SCLK: length 233.1
  TOP w0.14: v1(112.55,25.7) 112.74,25.52 112.74,25.52 113,25.25 113,24.88 112.65,24.52 110.17,24.52 109.63,25.07 108.87,25.07 108.5,24.7 108.5,21.14 106.62,19.26 106.62,15.74 107.59,14.77 107.59,7.61 106.59,6.6 89.36,6.6 88.93,7.03 88.93,8.31 C321.1 89.68,8.82 R373.1
  IN1 w0.089: v1(114.71,95.3) 113.72,94.31 113.72,93.03 111.65,90.96 109.19,90.96 108.18,89.94 99.87,89.94 v1(97.84,91.97)
  IN3 w0.127: v1(114.71,95.3) 114.33,94.92 114.33,92.25 115.48,91.11 119.16,91.11 119.6,90.66 119.6,87.11 120.11,86.6 120.11,83.52 120.43,83.2 120.43,82.06 121.16,81.33 121.8,81.33 122.31,80.82 125.22,80.82 125.91,80.13 129.87,80.13 131.29,78.71 131.29,75.28 132.92,73.65 136.86,73.65 137.63,72.87 139.4,72.87 139.93,73.4 141.28,73.4 142.48,72.2 153.83,72.2 154.48,72.85 162.72,72.85 163.16,72.4 163.16,69.3 161.33,67.47 161.33,63.88 161.32,63.86 161.32,58.22 161.11,58 161.11,56.02 161.87,55.26 161.87,50.07 160.37,48.57 160.37,38.47 158.9,37.01 152.9,37.01 152.78,36.88 151.67,36.88 150.46,35.67 149.33,35.67 147.83,34.17 143.69,34.17 143.42,33.89 142.09,33.89 138.28,30.08 128.57,30.08 128.09,30.57 117.92,30.57 116.54,29.18 113.74,29.18 113,28.44 113,26.11 112.59,25.7 v1(112.55,25.7)
  BOTTOM w0.14: v1(97.84,91.97) 97.84,90.38 98.51,89.7 R392.1 99.1,89.44 Q29.1 ; JDIM1.253 112.28,26.95 112.05,26.72 112.05,26.21 v1(112.55,25.7)
CLK_SDATA: length 240.5
  TOP w0.14: v1(112.55,25.07) 112.4,24.92 110.34,24.92 109.79,25.46 108.71,25.46 108.11,24.86 108.11,21.31 106.22,19.42 106.22,15.58 107.2,14.6 107.2,12.43 107.06,12.29 106.61,12.29 106.48,12.16 106.48,11.87 106.62,11.73 107.06,11.73 107.2,11.59 107.2,11.31 107.06,11.17 106.6,11.17 106.46,11.03 106.46,10.75 106.6,10.61 107.06,10.61 107.2,10.47 107.2,7.77 106.42,7 105.91,7 105.77,7.14 105.77,7.71 105.63,7.85 105.35,7.85 105.21,7.71 105.21,7.14 105.07,7 104.79,7 104.65,7.14 104.65,7.71 104.51,7.85 104.23,7.85 104.09,7.71 104.09,7.14 103.95,7 103.67,7 103.53,7.14 103.53,7.71 103.39,7.85 103.12,7.85 102.98,7.71 102.98,7.14 102.84,7 101.95,7 101.81,7.14 101.81,7.71 101.68,7.85 101.4,7.85 101.26,7.71 101.26,7.14 101.12,7 100.84,7 100.7,7.14 100.7,7.71 100.56,7.85 100.28,7.85 100.14,7.71 100.14,7.14 100,7 99.72,7 99.58,7.14 99.58,7.96 99.44,8.1 99.16,8.1 99.02,7.96 99.02,7.14 98.88,7 92.36,7 91.98,7.38 91.98,8.31 C322.1 92.72,8.82 R375.1
  IN1 w0.089: v1(115.09,94.28) 115.09,94.28 114.41,93.6 114.41,92.74 111.93,90.27 109.48,90.27 108.03,88.82 106.07,88.82 v1(105.84,88.59)
  IN3 w0.127: v1(112.55,25.07) 113.38,25.89 113.38,28.28 113.9,28.8 116.69,28.8 118.08,30.19 127.93,30.19 128.42,29.7 139.13,29.7 142.03,32.6 143.92,32.6 144.09,32.77 147.44,32.77 148.62,33.96 148.87,33.96 150.04,35.13 150.46,35.13 151.83,36.5 152.93,36.5 153.06,36.63 159.06,36.63 160.75,38.31 160.75,48.42 162.25,49.91 162.25,55.42 161.49,56.18 161.49,57.84 161.72,58.07 161.72,67.31 163.51,69.1 164.32,69.1 165.47,70.25 165.47,71.9 164.15,73.23 154.32,73.23 153.67,72.58 142.64,72.58 141.44,73.78 139.77,73.78 139.24,73.25 137.79,73.25 137.02,74.03 134,74.03 131.67,76.36 131.67,78.87 130.03,80.51 126.07,80.51 125.38,81.2 122.47,81.2 121.92,81.75 121.28,81.75 120.81,82.22 120.81,83.36 120.49,83.68 120.49,91.59 119.79,92.29 119.79,93.3 119.06,94.03 118.91,94.03 118.78,93.9 118.78,93.27 118.68,93.17 118.37,93.17 118.27,93.27 118.27,93.9 118.14,94.03 117.89,94.03 117.76,93.9 117.76,93.27 117.66,93.17 117.36,93.17 117.26,93.27 117.26,93.9 117.13,94.03 116.87,94.03 116.75,93.9 116.75,93.52 116.62,93.39 116.37,93.39 116.24,93.52 116.24,93.9 116.11,94.03 115.86,94.03 115.73,93.9 115.73,93.52 115.6,93.39 115.35,93.39 115.22,93.52 115.22,94.15 v1(115.09,94.28)
  BOTTOM w0.14: JDIM1.254 112.53,22.37 112.55,22.4 v1(112.55,25.07) ; Q29.4 102.9,90.74 R393.1 104.26,90.48 105.84,88.91 v1(105.84,88.59)
CLKRUN#: length 121.1
  TOP w0.14: v1(43.19,38.42) 43.32,38.28 R282.1
  IN1 w0.089: v1(95.43,81.93) 95.28,82.08 95.28,83.56 92.65,86.19 91.76,86.19 91.38,86.56 85.97,86.56 82.7,89.83 82.7,90.99 82.47,91.23 68.78,91.23 63.9,86.36 63.9,85.37 64.72,84.55 64.72,79.81 66.33,78.19 66.33,72.7 64.2,70.57 62.36,70.57 61.72,69.92 59.27,69.92 57.82,68.47 52.96,68.47 52.51,68.01 50.77,68.01 50.06,67.31 50.06,66.02 49.22,65.18 44.02,65.18 42.27,63.43 42.27,62.13 41.53,61.4 v1(41.28,61.4) ; v1(43.06,44.93) 44.18,43.82 44.18,39.41 v1(43.19,38.42)
  BOTTOM w0.089: R424.1 95.48,81.97 v1(95.43,81.93)
  BOTTOM w0.14: v1(41.28,61.4) 41.33,61.35 45.75,61.35 46.75,60.35 46.75,59.93 47.66,59.02 47.66,58.48 49.35,56.79 49.35,51.85 49.36,51.85 49.36,50.37 48.8,49.81 48.14,49.81 47.43,49.1 47.43,47.1 46.96,46.64 44.72,46.64 44.48,46.4 R539.1 43.6,45.47 v1(43.06,44.93)
CLR_CMOS: length 119.8
  TOP w0.127: v1(93.89,83.97) 94.27,83.97 94.55,84.25 Q2.2 Q2.5 ; v1(47.17,31.67) 47.1,31.67 46.34,30.91 v1(44.86,30.91) R298.1
  IN1 w0.089: v1(93.89,83.97) 94.9,82.96 94.9,81.34 96.31,79.93 96.31,79.53 96.64,79.2 97.09,79.2 97.7,79.81 98.32,79.81 98.83,79.3 98.83,78.42 98.32,77.9 95.89,77.9 92.64,81.14 91.67,81.14 89.96,82.85 85.3,82.85 84.13,84.02 84.13,85.56 81.18,88.52 72.71,88.52 70.66,86.46 70.66,80.33 68.58,78.26 68.58,71.42 63.91,66.74 61.19,66.74 59.77,65.32 59.77,64.97 55.34,60.55 55.34,59.5 54.37,58.53 54.37,56.1 53.19,54.91 v1(52.36,54.91)
  IN3 w0.127: v1(52.36,54.91) 53.19,54.91 54.26,53.84 54.26,42.21 49.39,37.34 48.9,37.34 47.66,36.1 47.66,33.78 46.83,32.95 46.83,32.01 v1(47.17,31.67)
CNVI_BRI_DT: length 6.1
  TOP w0.127: R75.1 103.29,76.12 R84.2 v1(104.1,75.36) 104.1,74.3 103.54,73.74 103.54,72.72 v1(103.01,72.19)
  BOTTOM w0.089: U22.H17 102.92,72.19 v1(103.01,72.19)
CNVI_WT_RCOMP: length 2.5
  TOP w0.152: R90.2 95.88,74.25 96.33,73.81 96.33,73.36 v1(95.92,72.95)
  BOTTOM w0.089: v1(95.92,72.95) 95.84,72.95 U22.F33
CODEC_VREF: length 2.6
  TOP w0.203: U16.28 180.48,21.8 180.8,22.12 180.8,22.6 C265.2
COMP_VCGI: length 3.6
  BOTTOM w0.127: v1(57.61,62.76) 57.45,62.92 PR204.2 55.91,62.92 PC185.1 55.79,63.04 55.11,63.72 PU10.23
COMP_VNN: length 3.7
  TOP w0.203: v1(31.86,61.52) 32.53,61.52 PR53.2 32.67,62.1 32.98,62.41 PU1.23
  BOTTOM w0.203: v1(31.86,61.52) 32.53,61.52 PR53.2
CORE_PWROK: length 39.5
  TOP w0.127: v1(98.08,79.04) 98.2,78.92 98.2,77.9 97.94,77.64 R68.2 97.88,77.45 R74.1 98.14,76.89 98.14,76.37 98.52,76 98.52,75.02 98.77,74.77 C78.2 99.45,74.39 99.45,73.13 v1(99.65,72.92) ; v1(79.33,78.29) 78.28,78.29 77.15,79.42 77.15,81.3 80.27,84.43 84.12,84.43 v1(84.54,84.85)
  IN1 w0.089: v1(98.08,79.04) 97.64,78.61 96.4,78.61 95.56,79.45 95.23,79.45 93.35,81.33 91.75,81.33 90.04,83.04 86.35,83.04 v1(84.54,84.85)
  BOTTOM w0.089: U22.D25 99.32,73.25 v1(99.65,72.92)
  BOTTOM w0.14: R445.2 79.72,77.9 v1(79.33,78.29)
CSCL: length 3.2
  TOP w0.127: R38.2 115.07,86.43 115.35,86.16 115.35,85.39 v1(115.48,85.27) 115.6,85.27 116.15,84.72 U6.29
CSDA: length 4.2
  TOP w0.127: U6.28 116.25,85.12 115.6,85.77 115.6,86.28 114.89,86.99 v1(114.89,87.25) 114.89,87.89 R27.2
D/C#: length 2.1
  TOP w0.178: PR112.2 148.5,7.15 TP44.1 PC106.2
DCIN_ENB: length 3.6
  TOP w0.127: R48.1 124.11,81.08 v1(123.98,81.2) 123.98,82.22 123.48,82.72 U6.3
DDR4_SUSON_2V5: length 115.4
  TOP w0.127: v1(24.94,38.73) 25.11,38.91 U14.126 ; PR118.1 v1(113.32,8.56)
  IN1 w0.089: v1(24.94,38.73) 24.94,38.09 25.15,37.88 25.15,37.07 25.58,36.63 25.58,30.63 26.53,29.68 26.53,26.88 26.7,26.72 26.7,18.5 33.23,11.96 33.23,10.54 33.6,10.16 40.67,10.16 41.07,9.77 58.63,9.77 59.93,8.46 65.45,8.46 66.04,7.87 82.5,7.87 83.59,8.96 112.92,8.96 v1(113.32,8.56)
DE1: length 4.4
  BOTTOM w0.127: R576.2 126.91,21.23 v1(127.49,21.82) 127.92,21.39 R577.1 128.42,21.51 129.32,21.51 129.45,21.65 U32.9
DE2: length 2.3
  BOTTOM w0.127: R578.2 R579.1 U32.8
DEW1: length 4.9
  BOTTOM w0.127: R569.2 R568.1 133.51,27.09 v1(133.39,26.97) 132.93,26.52 131.16,26.52 130.95,26.31 U32.20
DEW2: length 5.2
  BOTTOM w0.127: R563.2 129.45,26.83 U32.17 ; R563.2 128.94,28.36 v1(128.94,29.64) ; R563.2 R562.1
DMIC_CLK: length 127
  TOP w0.14: v1(152.09,81.25) 151.54,80.71 D1.2 151.21,80.36 151.04,80.19 151.04,79.68 150.9,79.54 R55.1 150.15,79.54 v1(149.64,80.06) ; R355.1 177.32,10.76 C320.1 176.82,11.03 v1(176.82,11.23)
  IN1 w0.089: v1(152.09,81.25) 152.53,81.69 156.21,81.69 157.88,80.02 173.08,80.02 173.92,79.18 173.92,76.23 174.52,75.63 174.52,71.59 174.52,71.31 171.16,67.95 171.16,61.66 172.78,60.04 172.78,55.7 167.97,50.89 167.97,50.31 167.53,49.87 167.53,41.99 166.67,41.13 166.67,36.64 165.18,35.14 165.18,32.14 167.32,29.99 167.32,21.82 166.85,21.35 166.85,20.56 166.58,20.29 165.79,20.29 165.6,20.09 165.6,18.61 161.1,14.11 160.72,14.11 160.13,13.52 160.13,10.24 161.29,9.08 169.01,9.08 172.63,12.69 175.35,12.69 v1(176.82,11.23)
