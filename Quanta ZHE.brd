# Allegro board Quanta ZHE.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 153.07,69.01 153.07,68.63 153.19,68.5 153.19,67.43 153.19,67.43 153.19,65.2 153.45,64.95 153.45,64.06 153.32,63.93 153.07,63.93 152.94,64.06 152.94,64.57 152.81,64.69 152.31,64.69 152.18,64.82 152.18,66.34 152.05,66.47 152.04,66.47 152.01,66.5 151.21,66.5 151.18,66.51 151.16,66.55 151.16,66.65 151.18,66.68 151.21,66.7 152.01,66.7 152.04,66.72 152.05,66.72 152.18,66.85 152.18,67.31 152.18,69.01 152.31,69.14 152.94,69.14
GND on BOTTOM (solid shape): 20.99,22.45 20.99,18.85 20.73,18.59 19.98,18.59 19.94,18.61 19.93,18.62 19.62,18.79 19.3,18.62 19.29,18.61 19.25,18.59 19.21,18.59 18.96,18.85 18.96,18.97 18.97,18.98 19.06,19.24 18.96,19.49 18.96,21.03 19.59,21.66 19.59,22.35 19.95,22.71 20.73,22.71
GND on BOTTOM (solid shape): 20.99,68.76 21.08,68.76 21.09,68.75 21.22,68.73 21.35,68.75 21.35,68.76 22.51,68.76 22.64,68.63 22.64,68.59 22.63,68.58 22.59,68.39 22.64,68.21 22.64,67.83 22.59,67.64 22.64,67.45 22.64,67.23 22.51,67.11 20.35,67.11 20.23,67.23 20.07,67.23 20.05,67.26 18.55,67.26 18.45,67.36 18.45,67.99 18.19,68.25 17.94,68.25 17.81,68.38 17.81,68.88 17.94,69.01 20.73,69.01
GND on BOTTOM (solid shape): 33.69,79.3 33.69,77.27 33.31,76.88 33.31,75.61 33.56,75.36 34.02,75.36 34.05,75.35 34.07,75.31 34.07,73.76 34.05,73.72 34.02,73.71 29.5,73.71 29.29,73.51 29.29,70.43 29.19,70.33 28.28,70.33 28.25,70.36 28.25,71.27 28.51,71.52 28.51,73.84 28.24,74.1 26.72,74.1 26.7,74.11 26.68,74.12 26.42,74.22 26.16,74.12 26.15,74.11 26.13,74.1 24.3,74.1 24.04,74.37 24.04,79.32 24.49,79.78 33.2,79.78
GND on BOTTOM (solid shape): 47.59,38.63 47.72,38.59 47.86,38.59 48.06,38.56 48.24,38.63 48.76,38.63 48.78,38.63 48.86,38.6 48.93,38.59 49.02,38.59 49.1,38.62 49.13,38.62 49.16,38.61 49.66,38.1 49.66,36 49.56,35.74 49.66,35.48 49.66,33.93 49.36,33.63 45.27,33.63 45.09,33.81 45.09,37.57 45.09,37.58 45.09,38.43 45.29,38.63
GND on BOTTOM (solid shape): 29.5,33.45 29.5,29.13 29.37,29.01 28.37,29.01 28.32,29.06 27.69,29.06 27.21,29.54 27.21,31.25 27.25,31.32 27.33,31.35 27.77,31.72 27.33,32.1 27.25,32.12 27.21,32.2 27.21,33.45 27.34,33.58 29.37,33.58
GND on BOTTOM (solid shape): 100.06,66.69 100.08,66.68 100.44,66.48 100.8,66.66 100.95,66.66 100.99,66.62 100.99,65.67 100.93,65.61 100.62,65.61 100.44,65.43 100.44,63.68 100.22,63.45 99.07,63.45 98.8,63.72 98.8,63.73 98.73,63.84 98.63,63.91 98.6,63.93 98.59,63.96 98.54,64.22 98.34,64.4 98.33,64.41 98.31,64.43 98.31,66.73 98.54,66.95 99.8,66.95
GND on BOTTOM (solid shape): 111.67,86.92 111.67,86.03 111.79,85.9 112.02,85.9 112.07,85.85 112.86,85.85 112.94,85.77 112.94,85.39 112.87,85.33 111.01,85.33 111,85.31 110.81,85.31 110.33,84.84 110.33,83.92 110.95,83.3 111.16,83.3 111.16,82.26 111.08,82.19 111.08,81.79 110.88,81.58 110.14,81.58 110.09,81.63 110.11,81.67 110.03,82.11 109.6,82.18 109.55,82.17 109.51,82.22 109.51,82.73 110.01,83.23 110.01,84 109.63,84.38 108.74,84.38 108.62,84.5 108.62,84.76 108.74,84.89 109.89,84.89 110.2,85.2 110.2,85.96 111.03,86.79 111.03,86.92 111.16,87.04 111.54,87.04
GND on BOTTOM (solid shape): 88.68,13.89 88.68,9.37 88.27,8.96 84.33,8.96 84.28,9.02 84.28,10.36 84.77,10.84 86.14,10.84 86.14,10.79 86.15,10.73 86.17,10.68 86.2,10.63 86.23,10.59 86.27,10.55 86.32,10.52 86.37,10.49 86.42,10.47 86.48,10.46 86.53,10.46 86.59,10.47 86.64,10.48 86.69,10.5 86.74,10.53 86.78,10.57 86.82,10.61 86.85,10.66 86.88,10.71 86.89,10.76 86.9,10.82 86.9,10.87 86.89,10.93 86.88,10.98 86.85,11.03 86.82,11.08 86.78,11.12 86.74,11.15 86.69,11.18 86.64,11.21 86.59,11.22 86.53,11.23 86.48,11.22 86.42,11.21 86.37,11.2 86.32,11.17 86.27,11.14 86.23,11.1 86.2,11.05 86.17,11.01 86.15,10.95 86.14,10.9 86.14,10.84 84.77,10.84 84.89,10.97 84.92,10.97 85.76,11.81 85.76,11.84 85.78,11.86 85.78,14.04 85.86,14.12 88.45,14.12
GND on BOTTOM (solid shape): 67.73,86.42 68.58,86.42 68.91,86.09 68.93,86.09 68.97,86.05 75.93,86.05 75.98,86 75.98,84.38 75.72,84.12 70.14,84.12 69.65,84.61 65.79,84.61 65.69,84.71 65.69,85.39 69.75,85.39 69.76,85.34 69.77,85.28 69.79,85.23 69.82,85.18 69.85,85.14 69.89,85.1 69.94,85.07 69.99,85.04 70.04,85.02 70.09,85.01 70.15,85.01 70.21,85.02 70.26,85.03 70.31,85.05 70.36,85.08 70.4,85.12 70.44,85.16 70.47,85.21 70.49,85.26 70.51,85.31 70.52,85.37 70.52,85.42 70.51,85.48 70.49,85.53 70.47,85.58 70.44,85.63 70.4,85.67 70.36,85.7 70.31,85.73 70.26,85.75 70.21,85.77 70.15,85.77 70.09,85.77 70.04,85.76 69.99,85.74 69.94,85.72 69.89,85.69 69.85,85.65 69.82,85.6 69.79,85.56 69.77,85.5 69.76,85.45 69.75,85.39 65.69,85.39 65.69,86.28 65.84,86.43 67.72,86.43
GND on BOTTOM (solid shape): 168.94,46.28 168.94,42.85 168.31,42.21 168.22,42.21 168.18,42.25 168.13,42.28 168.09,42.31 168.03,42.33 167.98,42.34 167.93,42.34 167.87,42.34 167.82,42.33 167.77,42.31 167.72,42.28 167.68,42.25 167.62,42.21 163.99,42.21 163.86,42.34 163.86,42.98 167.54,42.98 167.55,42.92 167.56,42.86 167.58,42.81 167.61,42.76 167.64,42.72 167.68,42.68 167.73,42.65 167.78,42.62 167.83,42.61 167.88,42.6 167.94,42.59 168,42.6 168.05,42.61 168.1,42.64 168.15,42.66 168.19,42.7 168.23,42.74 168.26,42.79 168.28,42.84 168.3,42.89 168.31,42.95 168.31,43 168.3,43.06 168.28,43.11 168.26,43.16 168.23,43.21 168.19,43.25 168.15,43.29 168.1,43.31 168.05,43.34 168,43.35 167.94,43.36 167.88,43.35 167.83,43.34 167.78,43.33 167.73,43.3 167.68,43.27 167.64,43.23 167.61,43.19 167.58,43.14 167.56,43.09 167.55,43.03 167.54,42.98 163.86,42.98 163.86,46.02 163.99,46.15 166.66,46.15 167.55,47.04 168.18,47.04
GND on BOTTOM (solid shape): 53.5,16.69 53.5,14.76 51.77,13.03 51.77,12.01 51.77,9.02 51.32,8.57 51.23,8.43 51.22,8.25 51.23,8.21 51.25,8.14 51.29,8.07 51.29,7.9 51.24,7.81 51.22,7.72 51.2,7.59 51.22,7.46 51.39,7.27 51.65,7.23 51.68,7.22 51.7,7.21 51.98,6.93 51.98,5.01 51.72,5.01 51.72,6.25 51.48,6.25 51.48,5.01 51.22,5.01 51.22,6.25 50.98,6.25 50.98,5.01 50.72,5.01 50.72,6.35 50.75,6.38 50.75,7.21 50.58,7.39 50.58,11.1 50.63,11.16 50.63,12.72 51.71,13.8 51.71,14.5 51.99,14.79 51.99,15.91 52.38,16.3 52.46,16.44 52.48,16.59 52.48,16.61 52.62,16.75 53.43,16.75
GND on BOTTOM (solid shape): 115.09,107.39 115.09,100.1 115.87,99.04 117.11,99.47 117.13,99.49 117.15,99.49 118.21,99.49 118.29,99.45 118.3,99.36 118.28,99.28 118.28,99.2 118.28,99 118.28,98.93 118.3,98.86 118.3,98.81 118.28,98.77 118.28,97.9 118.07,97.69 112.81,97.69 110.93,95.81 110.11,95.81 109.91,96.01 109.91,104.89 110.01,104.99 111.8,104.99 112.51,105.29 112.81,106 112.81,107.29 113.01,107.49 114.99,107.49
GND on BOTTOM (solid shape): 160.05,48.21 160.05,46.81 159.67,46.43 159.67,45.69 159.66,45.68 159.66,44.58 159.62,44.5 159.53,44.48 159.08,44.29 159.18,43.82 159.22,43.74 159.18,43.66 159.08,43.18 159.53,42.99 159.62,42.98 159.66,42.89 159.66,40.93 159.54,40.82 158.88,40.82 158.58,40.51 157.69,40.51 157.64,40.56 157.64,44.5 157.51,44.63 157.51,46.79 157.64,46.91 158.55,46.91 158.68,47.04 158.68,48.18 158.91,48.41 159.85,48.41
GND on BOTTOM (solid shape): 101,56.52 101.94,56.52 102.1,56.36 102.1,54.74 102.38,54.46 102.73,54.46 102.91,54.64 103.19,54.64 103.29,54.53 103.29,54.16 103.29,54.15 103.27,54.05 103.29,53.95 103.29,53.94 103.29,53.87 103.57,53.59 103.58,53.58 103.63,53.46 103.71,53.36 103.75,53.3 103.73,53.23 103.7,53.18 103.67,53.13 103.66,53.11 103.63,53.1 103.54,53.09 103.45,53.06 103.42,53.06 102.96,53.52 102.55,53.52 102.2,53.16 101.54,53.16 101.44,53.26 101.34,53.47 101.31,53.53 101.26,53.59 101.26,54.02 101.26,54.05 101.26,54.09 101.26,54.73 101.26,54.76 101.26,54.8 101.26,55.02 100.97,55.3 100.93,55.37 100.88,55.43 100.88,55.51 100.89,55.53 101.01,55.83 100.89,56.13 100.88,56.15 100.88,56.17 100.88,56.44 100.96,56.52 101,56.52
GND on BOTTOM (solid shape): 95.18,104.9 95.19,104.89 95.19,104.87 95.19,95.87 95.34,95.31 95.75,94.91 95.75,94.2 95.56,94.02 94.28,94.02 93.66,94.64 93.66,98.78 93.22,99.21 92.98,99.21 92.94,99.25 90.11,99.25 90.07,99.21 89.8,99.21 89.42,98.83 89.42,96.15 89.01,95.02 87.98,94.41 87.94,94.4 87.65,94.38 87.37,94.4 87.32,94.41 86.98,94.51 86.67,94.68 86.67,95.2 86.77,95.3 87.11,95.3 88.14,95.27 88.66,96.15 88.66,104.79 88.86,104.99 95.09,104.99
GND on BOTTOM (solid shape): 168.68,22.29 168.68,19.75 168.84,19.58 171.66,19.58 171.74,19.51 171.74,19.18 171.63,19.07 169.44,19.07 169.39,19.09 169.35,19.1 169.06,19.1 168.92,19.04 168.84,18.91 168.84,18.89 168.82,18.87 168.82,17.6 168.56,17.35 168.1,17.35 167.98,17.22 167.98,16.56 168.07,16.47 168.09,16.42 168.11,16.39 168.19,16.33 168.28,16.31 169.35,16.31 169.4,16.32 169.45,16.34 169.49,16.36 169.52,16.39 169.54,16.4 169.56,16.41 169.78,16.41 170.62,17.24 170.9,17.24 171.15,17.5 173.36,17.5 173.46,17.4 173.46,15.47 173.36,15.37 171.08,15.37 170.72,15.72 170.7,15.72 170.68,15.73 170.46,15.8 170.24,15.72 170.06,15.72 169.84,15.8 169.61,15.73 169.6,15.72 169.53,15.72 169.51,15.72 169.46,15.76 169.41,15.78 169.35,15.79 168.28,15.79 168.22,15.78 168.17,15.76 168.12,15.72 168.1,15.72 167.14,15.72 166.78,16.08 166.78,22.25 166.96,22.43 168.54,22.43
GND on BOTTOM (solid shape): 29.62,39.8 29.62,39.25 29.61,39.22 29.6,39.22 29.43,38.7 29.94,38.54 29.98,38.54 30,38.53 30.13,38.4 30.28,38.4 30.3,38.4 30.32,38.38 30.55,38.25 30.81,38.3 30.84,38.31 30.87,38.3 30.89,38.28 30.89,35.99 30.51,35.61 28.86,35.61 28.73,35.74 28.73,36.63 28.86,36.75 29.5,36.75 29.75,37.01 29.75,37.2 29.75,37.21 29.78,37.34 29.75,37.47 29.75,37.47 29.75,37.64 29.62,37.77 28.53,37.77 28.51,37.77 28.5,37.78 28.45,37.83 28.43,37.86 28.43,37.89 28.45,37.94 28.46,38 28.46,38.3 28.44,38.39 28.39,38.46 28.37,38.5 28.39,38.53 28.45,38.93 28.12,39.17 28.1,39.17 27.85,39.42 27.85,39.93 27.97,40.05 29.37,40.05
GND on BOTTOM (solid shape): outline of 93 points within 140.93,71.68 143.8,78.41
GND on BOTTOM (solid shape): outline of 185 points within 63.66,87.29 78.77,104.99
GND on BOTTOM (solid shape): outline of 191 points within 102.24,6.58 123.98,12.57
GND on BOTTOM (solid shape): outline of 94 points within 88.2,65.84 93.84,68.28
GND on BOTTOM (solid shape): outline of 281 points within 66.25,6.5 97.39,14.93
GND on BOTTOM (solid shape): outline of 159 points within 94.58,58.12 101,63.83
GND on BOTTOM (solid shape): outline of 338 points within 160.69,4.37 171.86,13.77
GND on BOTTOM (solid shape): outline of 409 points within 56.72,1.51 187.49,21.51
GND on BOTTOM (solid shape): outline of 123 points within 0.51,0.51 46.95,107.49
GND on BOTTOM (solid shape): outline of 442 points within 124.67,67.54 186.49,107.49
GND on BOTTOM (solid shape): outline of 1279 points within 94.55,67.11 103.28,75.08
GND on BOTTOM (solid shape): outline of 1386 points within 86.47,53.9 95.36,64.84
GND on BOTTOM (solid shape): outline of 1542 points within 101.2,60.15 109.73,68.35
GND on BOTTOM (solid shape): outline of 3158 points within 90.65,18.11 112.26,35.48
GND on BOTTOM (solid shape): outline of 4068 points within 47.42,17.88 84.21,34.77
GND on SGND (solid shape): outline of 2373 points within 0.51,0.51 187.49,107.49
GND on IN1 (solid shape): 32.04,91.06 32.04,88.54 31.96,88.47 29.39,88.47 29.24,88.62 29.24,91.13 29.32,91.21 31.88,91.21
GND on IN1 (solid shape): 32.54,83.74 32.54,81.66 32.39,81.51 29.05,81.51 28.86,81.69 28.86,83.47 29.41,84.02 29.54,84.02 29.64,84.12 32.16,84.12
GND on IN1 (solid shape): 119.72,69.62 119.72,66.17 119.69,66.14 115.27,66.14 115.09,66.32 115.09,68.57 115.1,68.59 115.11,68.6 116.2,69.7 119.64,69.7
GND on IN1 (solid shape): 175.2,53.43 184.44,53.43 184.85,53.02 184.85,52.3 184.46,51.91 175.26,51.91 174.02,53.15 173.22,53.15 173.21,53.14 171.25,53.14 171.25,53.63 171.95,54.32 174.31,54.32
GND on IN1 (solid shape): 100.12,84.5 100.24,84.48 100.35,84.5 100.36,84.5 100.87,84.5 100.88,84.5 101,84.48 101.11,84.5 101.12,84.5 101.51,84.5 102.27,83.74 102.27,82.09 102.14,81.96 99.09,81.96 98.84,82.22 98.84,84.38 98.97,84.5 100.11,84.5
GND on IN1 (solid shape): outline of 152 points within 161.58,9.83 175.04,21.26
GND on IN1 (solid shape): outline of 81 points within 70.64,90.78 103.39,104.99
GND on IN1 (solid shape): outline of 214 points within 109.91,62.41 186.49,107.49
GND on IN1 (solid shape): outline of 2361 points within 0.51,0.51 187.49,107.49
GND on SVCC (solid shape): outline of 82 points within 173.64,3.03 185.97,25.58
GND on SVCC (solid shape): 35.63,105.97 34.65,104.21 36.2,102.92 36.5,102.92 38.05,104.21 37.07,105.97 39.49,105.97 39.47,103.09 41.68,101.26 41.61,101.2 41.54,101.14 38.9,98.49 38.61,98.08 38.51,97.59 38.51,86.79 38.57,86.42 38.72,86.09 38.28,85.65 26.68,85.65 25.94,86.39 25.94,86.56 27.31,87.92 27.68,88.02 27.78,88.4 30.69,91.31 30.75,91.39 30.77,91.49 30.77,96.34 31.02,96.7 30.77,97.06 30.77,99.41 30.9,99.62 33.55,99.62 33.65,99.63 33.74,99.69 34.37,100.33 34.43,100.41 34.45,100.51 34.45,105.97
GND on SVCC (solid shape): outline of 615 points within 49.31,17.96 129.19,75.99
GND on IN2 (solid shape): 119.69,69.92 119.69,66.27 119.59,66.17 115.2,66.17 115.09,66.27 115.09,68.6 116.01,69.52 116.01,70 116.08,70.08 119.54,70.08
GND on IN2 (solid shape): 32.67,84 32.67,81.46 32.54,81.33 28.86,81.33 28.73,81.46 28.73,84 28.86,84.12 32.54,84.12
GND on IN2 (solid shape): 100.11,84.38 101.12,84.38 101.25,84.5 102.14,84.5 102.27,84.38 102.27,81.96 102.14,81.84 98.84,81.84 98.71,81.96 98.71,84.25 98.97,84.5 99.98,84.5
GND on IN2 (solid shape): 175.2,53.43 184.44,53.43 184.85,53.02 184.85,52.3 184.46,51.91 175.26,51.91 174.02,53.15 173.22,53.15 173.21,53.14 171.39,53.14 171.29,53.24 171.29,53.37 171.99,54.07 171.99,54.49 172.12,54.62 174.01,54.62
GND on IN2 (solid shape): 95.18,104.9 95.19,104.89 95.19,104.87 95.19,95.87 95.32,95.35 95.69,94.95 95.69,94.59 95.57,94.47 93.7,94.47 93.22,94.94 93.22,97.2 92.95,97.48 91.37,97.48 90.76,96.87 90.69,96.87 89.87,96.06 89.87,95.04 89.23,94.39 87.84,94.39 87.22,94.43 86.65,94.69 86.65,95.1 86.8,95.25 87.2,95.25 88.18,95.29 88.66,96.15 88.66,104.79 88.86,104.99 95.09,104.99
GND on IN2 (solid shape): 73.94,104.79 73.94,96.15 74.62,95.2 75.74,95.52 75.76,95.54 75.78,95.54 78.35,95.54 78.44,95.45 78.44,94.33 78.24,94.13 75.11,94.13 73.58,94.66 72.93,96.15 72.93,96.67 70.64,98.95 70.64,104.61 71.03,104.99 73.74,104.99
GND on IN2 (solid shape): outline of 569 points within 0.51,0.51 187.49,107.49
GND on IN2 (solid shape): outline of 1621 points within 109.91,59.76 186.49,107.49
GND on IN3 (solid shape): 102.27,83.54 102.27,81.96 102.14,81.84 98.84,81.84 98.79,81.89 98.79,83.49 99.07,83.77 102.04,83.77
GND on IN3 (solid shape): 119.69,69.52 119.69,67.24 118.59,66.14 115.27,66.14 115.09,66.32 115.09,68.35 116.49,69.75 119.46,69.75
GND on IN3 (solid shape): 32.38,83.53 32.38,81.67 32.04,81.33 28.86,81.33 28.73,81.46 28.73,84 28.86,84.12 31.78,84.12
GND on IN3 (solid shape): 175.2,53.43 184.44,53.43 184.85,53.02 184.85,52.3 184.46,51.91 175.26,51.91 174.02,53.15 173.22,53.15 173.21,53.14 171.43,53.14 171.27,53.3 171.27,53.72 172.46,54.91 173.72,54.91
GND on IN3 (solid shape): 73.94,104.79 73.94,96.15 74.62,95.2 75.74,95.52 75.76,95.54 75.78,95.54 78.39,95.54 78.52,95.41 78.52,94.53 78.12,94.13 73.59,94.13 72.3,95.43 72.3,97.33 70.77,98.86 70.77,104.61 71.15,104.99 73.74,104.99
GND on IN3 (solid shape): 95.18,104.9 95.19,104.89 95.19,104.87 95.19,95.87 95.35,95.29 95.79,94.89 95.79,94.64 95.44,94.3 94.89,94.3 93.5,95.68 93.5,97.08 93,97.59 91.53,97.59 89.14,95.2 88,94.42 86.65,94.69 86.65,95.17 86.81,95.34 87.05,95.34 88.11,95.25 88.66,96.15 88.66,104.79 88.86,104.99 95.09,104.99
GND on IN3 (solid shape): outline of 321 points within 165.65,9.32 175.55,18.72
GND on IN3 (solid shape): outline of 1233 points within 0.51,0.51 187.49,107.49
GND on IN3 (solid shape): outline of 1806 points within 109.86,67.61 186.49,107.49
GND on SGND1 (solid shape): outline of 2321 points within 0.51,0.51 187.49,107.49
VDD10 on BOTTOM (solid shape): outline of 809 points within 25.81,84.25 34.07,94.41
VDDREG/VDD33 on TOP (solid shape): 28.04,88.94 29.02,88.94 29.04,88.92 29.04,88.77 29,88.74 28.04,88.74 27.94,88.64 27.91,88.61 27.91,87.74 27.58,87.41 27.34,87.41 27.16,87.59 27.16,88.47 27.24,88.54 27.49,88.54 27.56,88.61 27.56,88.61 27.64,88.67 27.7,88.75 27.7,88.75 27.9,88.95 28.04,88.95
VDDREG/VDD33 on TOP (solid shape): 26.32,83.87 26.32,83.62 26.7,83.23 26.96,83.23 27.21,82.98 27.21,82.76 27.08,82.63 27.08,81.67 27.07,81.63 27.03,81.62 25.7,81.62 25.58,81.67 25.46,81.68 25.42,81.68 25.42,81.69 25.3,81.69 25.29,81.69 25.15,81.71 24.99,81.66 24.97,81.67 24.85,81.69 24.72,81.67 24.71,81.67 24.54,81.71 24.37,81.67 24.35,81.66 24.33,81.67 24.13,81.68 23.95,81.58 22.38,81.58 22.13,81.84 22.13,82.85 22.26,82.98 23.91,82.98 24.16,83.23 24.16,83.49 24.66,83.98 25.02,83.98 25.02,84.07 25.03,84.11 25.07,84.12 26.07,84.12
VDDREG/VDD33 on IN2 (solid shape): outline of 153 points within 24.95,81.58 28.1,88.52
1P35V_BOOT on BOTTOM (solid shape): 149.05,25.02 149.05,24.05 148.98,23.97 148.05,23.97 147.93,24.1 145.96,24.1 145.9,24.15 145.9,24.23 145.91,24.27 145.95,24.28 146.91,24.28 146.93,24.3 147.86,24.3 148.14,24.59 148.14,25.02 148.19,25.07 149,25.07
1P35V_LGATE on BOTTOM (solid shape): 146.54,26.2 146.54,25.88 145.99,25.33 145.61,25.33 145.51,25.44 145.51,26.24 145.65,26.38 146.36,26.38
1P35V_PHASE on BOTTOM (solid shape): 153.8,29.56 155.05,29.56 155.23,29.39 155.23,26.82 155.02,26.62 154.36,26.62 154.24,26.49 154.24,25.83 154.41,25.66 156.71,25.66 156.75,25.7 156.75,26.8 156.8,26.85 159.04,26.85 159.14,26.74 159.14,22.38 158.91,22.15 152.22,22.15 152.05,22.32 152.05,24.45 151.82,24.68 151.17,24.68 150.46,25.39 147.59,25.39 147.11,24.91 146.04,24.91 145.99,24.96 145.99,25.11 146.26,25.39 146.53,25.39 147.35,26.21 151.77,26.21 152.48,26.92 152.48,28.85 152.58,28.95 152.58,29.72 152.69,29.82 153.55,29.82
1P35V_UGATE on BOTTOM (solid shape): 156.46,26.81 156.46,26 156.28,25.82 154.5,25.82 154.36,25.96 154.36,26.36 154.46,26.47 155.18,26.47 155.58,26.87 156.39,26.87
1P35V_UGATE on BOTTOM (solid shape): 147.89,24.94 147.89,24.66 147.74,24.51 146.16,24.51 146.15,24.5 145.97,24.5 145.95,24.52 145.95,24.64 145.99,24.68 146.91,24.68 146.91,24.69 146.94,24.72 147.16,24.72 147.37,25.02 147.46,25.12 147.71,25.12
5671LX_1.24V on BOTTOM (solid shape): 133.26,73.33 133.26,71.93 133.51,71.68 133.94,71.68 134.53,71.68 134.65,71.55 134.65,71.47 134.64,71.44 134.6,71.42 133.94,71.42 133.94,71.18 134.6,71.18 134.64,71.16 134.65,71.13 134.65,70.97 134.64,70.94 134.6,70.92 133.94,70.92 133.94,70.68 134.6,70.68 134.64,70.66 134.65,70.63 134.65,69.9 133.26,68.5 129.95,68.5 129.7,68.76 129.7,73.33 129.83,73.46 133.13,73.46
24780_BST on TOP (solid shape): 140.37,12.24 140.37,11.73 140.39,11.71 140.39,11.65 140.84,11.2 140.89,11.16 140.95,11.14 140.96,11.14 141,11.1 141.51,11.1 141.64,10.97 141.75,10.97 141.78,10.94 142.6,10.94 142.64,10.93 142.65,10.89 142.65,10.8 142.64,10.76 142.6,10.74 141.78,10.74 141.75,10.72 141.15,10.72 141.14,10.72 141.02,10.74 140.9,10.73 140.88,10.73 140.86,10.73 140.62,10.97 139.73,10.97 139.61,11.1 139.61,12.24 139.73,12.37 140.24,12.37
24780_DH on TOP (solid shape): 140.7,10.67 140.74,10.69 140.78,10.67 140.83,10.61 141.23,10.61 141.26,10.59 141.75,10.59 141.78,10.56 141.78,10.54 142.6,10.54 142.64,10.53 142.65,10.49 142.65,10.39 142.64,10.35 142.6,10.34 142.58,10.34 142.58,10.34 141.78,10.34 141.78,10.34 141.51,10.34 141.15,9.98 141.13,9.97 141.11,9.97 140.99,9.98 140.87,9.96 140.86,9.96 140.75,9.96 140.62,10.08 140.62,10.59
24780_DL on BOTTOM (solid shape): 136.77,16.84 136.77,15.76 136.66,15.64 135.93,15.64 135.77,15.8 135.77,16.81 135.94,16.98 136.63,16.98
24780_LX on TOP (solid shape): 140.49,10.72 140.49,9.96 140.57,9.88 140.68,9.88 140.71,9.85 141.17,9.85 141.2,9.88 141.31,9.88 141.64,10.21 141.73,10.21 141.76,10.19 141.78,10.16 141.78,10.14 142.58,10.14 142.58,10.16 142.65,10.08 142.65,10 142.64,9.96 142.6,9.94 141.78,9.94 141.78,9.9 141.76,9.86 141.73,9.85 141.68,9.85 141.66,9.83 141.66,9.83 141.38,9.55 141.38,9.45 141.13,9.19 140.88,9.19 140.62,9.45 139.73,9.45 139.71,9.46 139.7,9.48 139.69,9.68 139.61,9.82 139.61,10.72 139.73,10.84 140.37,10.84
24780_LX on BOTTOM (solid shape): 135.34,19.2 135.34,16.23 135.16,16.05 133.2,16.05 132.74,15.59 132.74,14.6 132.87,14.47 133.46,14.47 133.63,14.31 133.63,12.35 133.32,12.04 128.7,12.04 128.45,12.29 128.45,18.79 128.66,19 132.9,19 133,19.1 134.25,19.1 134.53,19.38 135.16,19.38
24780_VCC on TOP (solid shape): 142.65,9.7 142.65,9.57 141,7.92 140.62,7.92 140.49,7.8 140.49,6.91 139.99,6.4 138.21,6.4 138.08,6.53 138.08,8.05 138.21,8.18 139.48,8.18 139.61,8.3 139.61,9.19 139.73,9.32 140.49,9.32 140.75,9.07 141.26,9.07 141.76,9.57 141.76,9.7 141.79,9.73 142.57,9.73 142.58,9.73 142.62,9.73
61087SW on BOTTOM (solid shape): 169.96,75.36 169.96,72.95 168.82,71.8 168.82,69.65 168.69,69.52 168.61,69.52 168.57,69.53 168.56,69.57 168.56,70.4 168.34,70.4 168.34,69.57 168.32,69.53 168.28,69.52 167.67,69.52 167.55,69.65 167.55,73.07 167.42,73.2 167.09,73.2 167.09,73.2 165.77,73.2 165.64,73.33 165.64,75.36 165.77,75.49 169.83,75.49
+601_VCC on TOP (solid shape): outline of 353 points within 126.4,19.48 138.75,30.02
+601_VCC on BOTTOM (solid shape): 131.47,22.77 131.48,22.76 131.66,22.64 131.88,22.6 132.75,22.6 132.9,22.45 133.59,22.45 134.27,21.77 137.45,21.77 137.57,21.64 137.57,20.88 137.46,20.77 136.81,20.77 136.8,20.75 132.87,20.75 131.99,21.64 130.97,21.64 130.81,21.79 130.81,22.63 130.97,22.78 131.44,22.78
+AZA_VDD on TOP (solid shape): 176.18,22.78 176.18,22.2 176.74,21.64 177.3,21.64 177.35,21.59 177.35,20.65 177.32,20.62 176.31,20.62 175.04,21.89 175.04,22.78 175.17,22.91 176.05,22.91
+AZA_VDD on TOP (solid shape): 177.32,15.29 177.32,14.4 175.93,13 170.21,13 170.1,13.11 170.1,13.79 170.21,13.89 175.04,13.89 175.21,14.07 175.25,14.07 175.27,14.05 175.74,14 175.99,14.4 175.99,14.65 176.35,15.01 176.35,15.21 176.51,15.36 176.57,15.39 176.63,15.42 177.2,15.42
+AZA_VDD on IN1 (solid shape): outline of 154 points within 175.04,14.15 178.34,22.4
+AZA_VDD on IN2 (solid shape): outline of 162 points within 175.04,14.15 178.34,22.26
+AZA_VDD on IN3 (solid shape): outline of 154 points within 175.04,14.15 178.34,22.4
+G_SEN_PW on TOP (solid shape): outline of 116 points within 86.9,7.29 100.67,17.07
+LCDVCC_1 on TOP (solid shape): 160.94,78.28 160.94,77.39 160.94,76.63 160.81,76.5 158.2,76.5 158.16,76.52 158.15,76.55 158.15,76.76 157.12,76.76 156.5,77.39 156.5,77.9 156.62,78.03 157.77,78.03 158.02,77.77 158.91,77.77 159.54,78.41 160.81,78.41
+TPVDD_1 on TOP (solid shape): 78.53,15.61 78.57,15.59 78.58,15.56 78.58,12.95 78.9,12.64 78.9,12.5 79.03,12.37 79.19,12.37 79.2,12.36 79.3,12.32 79.42,12.3 79.54,12.32 79.65,12.37 80.22,12.37 80.99,12.37 81.05,12.3 82.32,12.3 82.43,12.32 82.54,12.36 82.55,12.37 82.71,12.37 82.84,12.5 82.84,12.64 83.2,13 83.22,13 83.34,12.88 83.34,8.69 83.19,8.53 78.92,8.53 78.8,8.66 78.8,9.4 78.87,9.47 81.31,9.47 81.95,10.11 81.95,10.34 81.97,10.42 81.99,10.48 82.01,10.56 82.02,10.64 82.02,11.4 81.95,11.47 81.95,11.61 81.82,11.73 81.69,11.73 81.6,11.82 79.67,11.82 79.53,11.8 79.4,11.73 79.15,11.73 79.11,11.75 79.1,11.78 79.1,11.92 78.57,12.45 78.44,12.45 78.4,12.47 78.39,12.5 78.39,13.77 77.63,14.53 77.63,15.45 77.79,15.61
+TPVDD_1 on BOTTOM (solid shape): 82.43,16.97 82.44,16.96 83.75,16.96 83.75,16.97 84.16,16.97 85.12,16 85.15,16 85.16,15.99 85.49,15.94 85.73,16.17 85.74,16.18 85.78,16.23 86.85,16.23 87.28,15.8 89.44,15.8 89.57,15.67 89.57,14.65 89.31,14.4 85.76,14.4 85.63,14.27 85.63,11.86 84.87,11.1 82.71,11.1 82.58,11.23 82.58,11.61 82.84,11.86 82.84,13 82.96,13.13 83.6,13.13 83.73,13.26 83.73,16.2 83.59,16.34 83.59,16.34 83.36,16.57 83.24,16.69 81.92,16.69 81.79,16.56 81.79,15.49 81.72,15.42 81.21,15.42 81.13,15.49 81.13,15.85 81.31,16.03 81.31,16.06 81.32,16.07 81.38,16.31 81.32,16.54 81.31,16.55 81.31,16.58 81.21,16.69 81.17,16.69 81.16,16.69 80.92,16.76 80.69,16.69 79.84,16.69 79.71,16.56 79.71,15.54 79.58,15.42 79.23,15.42 79.1,15.54 79.1,16.89 79.41,17.19 82.2,17.19
+VNN on TOP (solid shape): 94.6,63.32 94.6,62.1 94.57,62.08 94.27,62.08 93.33,63.02 93.33,63.32 93.49,63.48 94.44,63.48
+VNN on TOP (solid shape): 99.09,63.42 99.09,63.12 98.91,62.94 98.89,62.94 98.54,62.52 98.98,62.18 99.06,62.16 99.09,62.08 99.09,61.64 99.03,61.58 98.8,61.58 98.48,61.26 98.48,61.03 98.33,60.88 98.08,60.88 97.95,61.01 97.95,61.31 97.97,61.33 97.97,62.27 97.95,62.3 97.95,63.42 98.08,63.55 98.97,63.55
+VNN on TOP (solid shape): 89.74,62.78 89.74,61.87 89.74,61.78 89.74,61.69 89.74,60.68 89.69,60.63 88.07,60.63 88.07,60.63 87.31,60.63 87.23,60.7 87.23,60.79 87.77,61.33 87.92,61.57 87.96,61.88 87.97,61.9 88.18,62.11 88.2,62.12 88.54,62.34 88.67,62.73 88.67,62.84 88.68,62.87 88.72,62.89 89.64,62.89
+VNN on TOP (solid shape): 44.95,71.78 44.98,71.76 45,71.73 45,71 46,71 46.04,70.98 46.06,70.95 46.06,65.5 46.01,65.45 45.12,65.45 44.74,65.07 44.74,64.29 44.61,64.16 43.9,64.16 43.75,64.31 43.75,65.11 43.43,65.43 42.93,65.43 42.78,65.57 42.78,67.97 42.88,68.25 42.78,68.52 42.78,69.5 42.88,69.77 42.78,70.05 42.78,71.61 42.95,71.78
+VNN on TOP (solid shape): 72.42,58.07 72.43,58.05 72.43,58.03 72.86,57.58 73.14,58.14 73.14,58.24 73.23,58.29 73.35,58.29 73.36,58.29 73.51,58.25 73.66,58.29 73.67,58.29 77.17,58.29 77.38,58.09 77.38,53.14 77.05,52.81 70.33,52.81 70.29,52.86 70.29,54.38 70.31,54.41 71.15,54.41 71.28,54.53 71.28,54.73 71.28,58.16 71.41,58.29 72.2,58.29
+VNN on BOTTOM (solid shape): 89.95,63.22 89.95,62.18 89.74,61.97 89.74,61.64 89.24,61.14 88.27,61.14 88.17,61.24 88.17,61.62 88.65,62.1 88.65,62.43 88.53,62.56 88.53,62.86 88.68,63.02 88.68,63.22 88.78,63.32 89.85,63.32
+VNN on BOTTOM (solid shape): 47.28,76.54 47.28,73.07 46.9,72.69 46.9,71.8 46.26,71.17 46.26,65.58 46.13,65.45 42.83,65.45 42.7,65.58 42.7,67.87 42.71,67.9 42.72,67.91 42.88,68.25 42.72,68.58 42.71,68.6 42.7,68.62 42.7,69.4 42.71,69.42 42.72,69.44 42.88,69.77 42.72,70.11 42.71,70.12 42.7,70.15 42.7,71.22 42.76,71.42 42.71,71.62 42.7,71.63 42.7,71.93 42.72,71.94 42.72,73.4 43.68,74.36 43.68,76.53 43.91,76.77 47.05,76.77
+VNN on BOTTOM (solid shape): 98.28,63.53 98.3,63.52 98.32,63.5 98.39,63.43 98.49,63.39 98.5,63.39 98.69,63.2 98.69,62.95 98.69,62.93 98.67,62.91 98.49,62.56 98.67,62.21 98.69,62.19 98.69,62.17 98.69,61.5 98.69,61.48 98.67,61.46 98.49,61.11 98.67,60.76 98.69,60.74 98.69,60.72 98.69,60.68 98.59,60.58 97.7,60.58 97.57,60.71 97.57,62.14 97.58,62.16 97.6,62.18 97.84,62.57 97.6,62.95 97.58,62.97 97.57,63 97.57,63.09 97.89,63.41 97.96,63.45 98,63.5 98.02,63.52 98.04,63.53
+VNN on IN1 (solid shape): outline of 812 points within 86.06,60.26 98.84,63.8
+VNN on SVCC (solid shape): outline of 372 points within 42.7,54.41 89.95,77.01
+VNN on IN2 (solid shape): outline of 281 points within 88.42,61.14 94.49,64.18
+VNN on IN3 (solid shape): outline of 567 points within 92.67,59.08 98.46,63.43
+VREF_CA_CPU on BOTTOM (solid shape): 95.76,18.9 95.76,17.83 95.72,17.7 95.71,17.58 95.71,17.27 95.61,17.17 93.99,17.17 93.91,17.24 93.91,17.96 93.96,18.01 94.88,18.01 95.26,18.39 95.26,18.41 95.26,18.9 95.33,18.97 95.69,18.97
ADOGND on TOP (solid shape): 186.42,33.52 186.5,33.51 187.29,33.51 187.49,33.31 187.49,22.27 187.26,22.05 186.29,22.05 185.76,22.58 185.76,33.35 185.93,33.53 186.4,33.53
ADOGND on BOTTOM (solid shape): outline of 400 points within 173.01,22.05 187.49,51.51
ADOGND on SGND (solid shape): outline of 150 points within 169.45,14.02 187.49,52.5
ADOGND on IN1 (solid shape): outline of 341 points within 172.88,22.05 187.49,47.89
ADOGND on SVCC (solid shape): outline of 134 points within 169.45,14.02 185.97,52.5
ADOGND on IN2 (solid shape): outline of 308 points within 172.88,22.05 187.49,46.46
ADOGND on IN3 (solid shape): outline of 381 points within 169.96,22.05 187.49,52.5
ADOGND on SGND1 (solid shape): outline of 140 points within 169.45,14.02 187.49,52.5
BAT-V on TOP (solid shape): 91.6,16.36 91.6,14.5 91.75,14.35 91.78,14.35 91.81,14.32 91.87,14.3 91.92,14.28 91.98,14.27 92.04,14.27 92.08,14.28 92.11,14.27 92.16,14.22 92.16,13.56 89.69,11.1 89.19,11.1 88.93,11.35 88.93,14.64 90.52,14.64 90.52,14.58 90.54,14.53 90.56,14.48 90.58,14.43 90.62,14.39 90.66,14.35 90.7,14.31 90.75,14.29 90.8,14.27 90.86,14.26 90.92,14.26 90.97,14.26 91.02,14.28 91.08,14.3 91.12,14.33 91.17,14.37 91.2,14.41 91.23,14.45 91.26,14.5 91.27,14.56 91.28,14.61 91.28,14.67 91.27,14.72 91.26,14.78 91.23,14.83 91.2,14.87 91.17,14.92 91.12,14.95 91.08,14.98 91.02,15 90.97,15.02 90.92,15.02 90.86,15.02 90.8,15.01 90.75,14.99 90.7,14.97 90.66,14.93 90.62,14.9 90.58,14.85 90.56,14.8 90.54,14.75 90.52,14.7 90.52,14.64 88.93,14.64 88.93,16.41 89.03,16.51 91.45,16.51
BAT-V on BOTTOM (solid shape): outline of 82 points within 89.29,8.18 120.89,16.69
BAT-V on IN1 (solid shape): outline of 617 points within 89.67,9.92 119.68,15.73
BOOT_VCGI on BOTTOM (solid shape): 53.18,69.22 53.21,69.19 53.21,68.19 53.17,68.15 51.84,68.15 51.66,68.33 51.66,69.15 51.72,69.21 53.13,69.21 53.15,69.22
BOOT_VNN on TOP (solid shape): 36.56,69.09 36.56,67.72 36.5,67.6 36.48,67.48 36.47,67.45 36.2,67.18 34.93,67.18 34.9,67.2 34.88,67.23 34.88,68.15 34.98,68.25 35.49,68.25 35.8,68.55 35.8,69.04 35.92,69.16 36.48,69.16
CARD_3V3 on TOP (solid shape): 163.24,42.56 163.24,42.42 163.16,42.33 162.25,42.33 162.18,42.27 162.18,41.66 162.47,41.37 162.47,38.66 162.67,38.45 162.88,38.45 163.19,38.15 163.68,38.15 163.7,38.14 163.72,38.13 164.97,36.88 165.77,36.88 165.98,36.95 166.12,37.13 166.17,37.16 167.06,37.16 167.7,36.52 167.7,35.71 169.48,33.93 169.48,33.4 169.35,33.27 168.64,33.27 168.08,33.83 167.95,33.83 167.32,34.47 166.87,34.47 166.78,34.55 166.78,35.65 166.26,36.18 164.31,36.18 164.29,36.18 164.27,36.2 163.28,37.19 163.23,37.19 163.1,37.32 163.04,37.32 162.82,37.54 161.4,37.54 161.35,37.59 161.35,41.86 162.12,42.63 163.17,42.63
CARD_3V3 on BOTTOM (solid shape): 171.61,21.26 172.63,21.26 172.88,21 172.88,19.86 172.75,19.73 171.5,19.73 171.48,19.73 169.07,19.73 168.97,19.84 168.97,22.43 169.07,22.53 170.34,22.53
CARD_3V3 on IN1 (solid shape): outline of 163 points within 166.94,21.39 170.97,39.55
CCD_PWR on TOP (solid shape): 168.56,81.08 168.56,80.82 168.43,80.69 168.43,77.27 168.31,77.14 168.02,77.14 167.86,77.2 167.7,77.2 167.49,77.41 167.49,78.21 167.63,78.36 167.67,78.55 167.67,80.44 167.42,80.69 167.42,81.08 167.55,81.2 168.43,81.2
CCD_PWR on BOTTOM (solid shape): 168.56,81.08 168.56,80.82 168.29,80.55 168.25,80.55 168.25,80.51 168.19,80.45 168.11,80.45 168.11,79.35 168.05,79.3 167.91,79.3 167.87,79.31 167.86,79.35 167.86,80.45 167.61,80.45 167.61,79.48 167.55,79.38 167.44,79.41 167.42,79.42 167.42,81.08 167.55,81.2 168.43,81.2
G5335-LX-1 on BOTTOM (solid shape): 140.75,83.49 140.75,83.11 143.54,80.31 143.54,79.42 143.67,79.3 144.18,79.3 144.3,79.17 144.3,76.63 144.05,76.38 144.05,75.49 143.98,75.41 143.9,75.36 143.42,75.36 143.29,75.49 143.29,75.51 143.81,75.51 143.81,76.29 143.56,76.29 143.56,75.51 143.29,75.51 143.29,78.41 143.16,78.54 141.43,78.54 141.41,78.55 141.35,78.57 141.3,78.58 141.24,78.59 141.18,78.58 141.12,78.57 141.06,78.55 141.03,78.54 140.88,78.54 140.77,78.43 140.77,77.06 140.72,77.01 138.97,77.01 138.84,77.14 138.84,78.78 143.08,78.78 143.08,79.02 142.29,79.02 142.29,78.78 138.84,78.78 138.84,80.69 139.86,81.71 139.86,83.49 139.99,83.62 140.62,83.62
G5719LX1.8V on BOTTOM (solid shape): 19.72,65.28 20.81,65.28 20.83,65.25 20.83,63.3 20.71,63.17 18.7,63.17 18.57,63.3 18.57,65.81 18.68,65.91 19.08,65.91
G5719LX2.5V on TOP (solid shape): 113.95,14.27 113.95,11.73 114.21,11.48 114.21,10.97 114.08,10.84 112.68,10.84 112.55,10.97 112.55,13 111.92,13.64 111.92,14.02 112.3,14.4 113.82,14.4
HDMI_5V on BOTTOM (solid shape): 122.49,96.04 122.49,94.41 122.41,94.33 120.91,94.33 120.25,93.67 120.17,93.67 120.08,93.76 119.08,93.76 119.05,93.78 119.03,93.81 119.03,96.04 119.11,96.11 122.41,96.11
HDMI_5V on IN1 (solid shape): outline of 245 points within 119.89,93.66 128.94,98.22
L_SPK+ on TOP (solid shape): 163.86,11.07 163.86,8.94 163.74,8.81 162.52,8.81 162.48,8.83 162.47,8.86 162.47,11.76 162.57,11.86 163.07,11.86
L_SPK+ on TOP (solid shape): 176.85,18.27 176.85,18.12 176.82,18.09 175.88,18.09 175.86,18.07 175.56,18.07 175.19,17.7 174.07,17.7 173.95,17.83 173.95,18.08 174.07,18.21 175.06,18.21 175.14,18.29 176.84,18.29
L_SPK+ on IN1 (solid shape): 173.9,18.46 174.91,18.46 175.04,18.34 175.04,17.96 174.91,17.83 170.85,17.83 170.82,17.85 170.81,17.92 170.56,18.17 170.22,18.09 170.21,18.08 170.17,18.07 170.13,18.09 169.74,18.25 169.48,17.93 169.44,17.86 169.37,17.83 168.05,17.83 166.66,16.43 165.89,16.43 163.74,14.27 163.74,10.72 163.61,10.59 162.72,10.59 162.59,10.72 162.59,14.26 165.78,17.45 166.15,17.45 167.67,18.97 173.39,18.97
L_SPK+_CN on TOP (solid shape): 164.12,7.92 164.12,6.67 164.12,6.65 164.12,6.02 163.86,5.76 163.86,5.51 163.74,5.38 163.48,5.38 162.59,6.27 162.59,7.92 162.72,8.05 163.99,8.05
L_SPK+_CN on BOTTOM (solid shape): 164.57,10.46 164.61,10.45 164.62,10.41 164.62,7.26 164.37,7.01 164.36,7.01 164.17,6.84 164.12,6.59 164.12,6.52 164.12,6.37 164,6.24 163.1,6.24 162.97,6.37 162.97,10.34 163.1,10.46
L_SPK- on TOP (solid shape): 165.89,11.25 165.89,8.94 165.77,8.81 164.5,8.81 164.37,8.94 164.37,11.21 164.56,11.4 165.74,11.4
L_SPK- on TOP (solid shape): 176.38,17.89 176.48,17.79 176.38,17.69 175.73,17.69 175.18,17.14 174.02,17.14 173.95,17.22 173.95,17.45 174.02,17.52 175.28,17.52 175.64,17.89
L_SPK- on IN1 (solid shape): outline of 165 points within 164.5,10.59 175.17,17.45
L_SPK-_CN on TOP (solid shape): 166.02,7.92 166.02,5.76 165.77,5.51 165.13,5.51 164.88,5.76 164.88,6.65 164.78,6.91 164.51,7.05 164.5,7.08 164.5,8 164.51,8.04 164.55,8.05 165.89,8.05
L_SPK-_CN on BOTTOM (solid shape): 166.02,10.34 166.02,6.34 165.93,6.25 165.02,6.25 164.88,6.39 164.88,6.78 165.01,6.91 165.01,10.34 165.13,10.46 165.89,10.46
LANCT3 on TOP (solid shape): 41.61,97.51 41.61,94.79 41.76,94.64 43.06,94.64 43.21,94.49 43.21,85.39 43.16,85.34 38.08,85.34 37.88,85.55 37.88,87.9 37.98,88.16 37.88,88.42 37.88,90.78 37.88,90.8 37.9,90.82 38.03,91.11 37.9,91.4 37.88,91.42 37.88,91.44 37.88,93.77 37.88,93.79 37.89,93.81 37.99,94.19 37.69,94.45 37.68,94.46 37.65,94.49 37.65,97.53 37.83,97.71 41.41,97.71
LANVCC on TOP (solid shape): 24.29,96.85 24.29,95.17 24.24,95.12 23.04,95.12 22.97,95.2 22.97,96.82 23.04,96.9 24.24,96.9
LANVCC on TOP (solid shape): 33.69,87.27 33.69,85.52 33.51,85.34 32.85,85.34 32.8,85.39 32.8,86.28 31.99,87.09 31.99,88.14 32.04,88.19 32.77,88.19
LANVCC on TOP (solid shape): 28.73,82.47 28.73,80.69 25.94,77.9 25.05,77.9 24.92,78.03 24.92,79.55 24.54,79.93 24.54,80.82 24.67,80.95 24.7,80.95 24.71,80.95 24.91,80.93 25.1,81.02 25.17,81.04 25.23,81.02 25.58,80.93 25.84,81.17 25.85,81.18 25.87,81.2 27.34,81.2 27.46,81.33 27.46,82.47 27.59,82.6 28.61,82.6
LANVCC on IN1 (solid shape): outline of 567 points within 23.04,81.71 32.93,100
LCDVCC on TOP (solid shape): 161.58,82.22 161.58,80.82 161.56,80.81 161.56,79.92 160.81,79.17 159.54,79.17 159.49,79.22 159.49,80.52 159.57,80.6 159.75,80.76 159.8,81 159.8,81.45 160.69,82.35 161.45,82.35
LCDVCC on TOP (solid shape): 170.09,81.71 170.09,81.61 170.03,81.56 170.02,81.55 169.76,81.4 169.61,81.14 169.6,81.13 169.58,81.1 169.58,80.95 169.58,80.14 169.63,80.09 169.63,79.73 169.58,79.68 168.94,79.68 168.82,79.8 168.82,80.52 168.94,80.64 168.94,80.66 168.94,81.23 168.59,81.58 168.59,81.58 168.56,81.61 168.56,81.71 168.69,81.84 169.96,81.84
LCDVCC on BOTTOM (solid shape): 170.34,82.85 170.34,81.33 170.31,81.3 170.29,81.3 170.25,81.3 170.2,81.3 170.15,81.3 170.09,81.28 170.05,81.26 170,81.23 169.96,81.2 169.93,81.16 169.9,81.11 169.88,81.07 169.86,81.02 169.86,80.96 169.86,80.91 169.86,80.87 169.86,80.85 169.85,80.84 169.58,80.57 169.58,79.17 169.45,79.04 168.43,79.04 168.31,79.17 168.31,79.27 168.34,79.3 169.36,79.3 169.36,80.45 169.11,80.45 169.11,79.3 168.86,79.3 168.86,80.45 168.61,80.45 168.61,79.3 168.36,79.3 168.36,80.36 168.69,80.69 168.69,81.33 168.56,81.46 162.21,81.46 162.01,81.33 161.96,81.33 161.9,81.33 161.85,81.32 161.8,81.3 161.75,81.27 161.71,81.24 161.67,81.2 161.64,81.15 161.61,81.11 161.59,81.05 161.58,81 161.57,80.95 161.58,80.89 161.59,80.85 161.58,80.83 161.45,80.69 159.93,80.69 159.8,80.82 159.8,82.88 159.9,82.98 170.21,82.98
LGND on TOP (solid shape): outline of 109 points within 42.27,92.68 70.52,107.49
PHASE_VCGI on BOTTOM (solid shape): 57.13,82.09 57.17,82.08 57.18,82.04 57.18,78.28 59.47,76 59.47,71.3 59.34,71.17 58.09,71.17 58.07,71.17 58.05,71.18 57.82,71.28 57.58,71.22 56.86,71.22 56.81,71.17 54.77,71.17 54.39,71.55 54.39,71.79 54.4,71.82 54.42,71.84 54.64,72.19 54.42,72.53 54.4,72.54 54.39,72.56 54.39,74.6 54.13,74.85 53.37,74.85 53.25,74.98 53.25,78.28 54.26,79.3 54.26,81.71 54.64,82.09
PHASE_VNN on TOP (solid shape): 37.98,70.48 37.98,68.35 37.9,68.27 36.94,68.27 36.86,68.35 36.86,69.24 36.67,69.43 34.72,69.43 34.27,68.98 34.27,68.71 34.1,68.54 34.07,68.52 34.03,68.54 33.61,68.96 33.61,70.23 33.76,70.38 34.55,70.38 34.91,70.74 37.73,70.74
PHASE_VNN on BOTTOM (solid shape): 39.66,77.44 39.66,72.13 39.48,71.96 39.48,70.95 39.33,70.8 38.44,70.8 38.27,70.64 37.52,70.64 37.47,70.69 37.47,72.41 36.66,73.23 34.93,73.23 34.53,73.63 34.53,76.43 34.63,76.53 35.9,76.53 36.4,77.04 36.4,77.93 36.48,78 39.1,78
R_SPK+ on TOP (solid shape): 169.83,11.27 169.83,9.02 169.67,8.86 169.66,8.83 169.62,8.81 168.56,8.81 168.43,8.94 168.43,11.2 168.63,11.39 169.71,11.39
R_SPK+ on TOP (solid shape): 176.38,17.09 176.48,16.99 176.38,16.89 175.79,16.89 175.11,16.21 175.11,15.97 174.94,15.8 174.05,15.8 173.95,15.9 173.95,16.23 174.02,16.31 174.96,16.31 175.75,17.09
R_SPK+ on IN3 (solid shape): 175.04,16.05 175.04,15.29 170.34,10.59 168.69,10.59 168.56,10.72 168.56,10.97 169.66,12.07 169.77,12.09 169.83,11.99 170.48,11.72 170.21,12.37 170.11,12.43 170.13,12.54 173.77,16.18 174.91,16.18
R_SPK+_CN on TOP (solid shape): 169.6,7.97 169.6,6.27 169.6,5.92 169.6,5.66 169.45,5.51 168.43,5.51 168.31,5.64 168.31,6.4 168.31,7.92 168.43,8.05 169.53,8.05
R_SPK+_CN on BOTTOM (solid shape): 169.32,10.34 169.32,6.53 169.32,6.52 169.32,6.35 169.21,6.24 168.25,6.24 168.21,6.28 168.21,7.04 168.2,7.05 168.2,8.03 167.67,8.56 167.67,10.41 167.69,10.45 167.72,10.46 169.2,10.46
R_SPK- on TOP (solid shape): 167.93,11.3 167.93,8.94 167.8,8.81 166.53,8.81 166.4,8.94 166.4,11.11 166.69,11.4 167.83,11.4
R_SPK- on TOP (solid shape): 176.38,17.49 176.48,17.39 176.38,17.29 175.76,17.29 174.93,16.46 174.1,16.46 173.95,16.61 173.95,16.86 174,16.91 175.1,16.91 175.67,17.49
R_SPK- on IN3 (solid shape): outline of 126 points within 166.66,10.59 175.04,17.32
R_SPK-_CN on TOP (solid shape): 167.93,7.92 167.93,6.56 167.93,5.76 167.67,5.51 166.91,5.51 166.69,5.73 166.69,6.28 166.78,6.53 166.69,6.77 166.69,7 166.4,7.29 166.4,7.92 166.53,8.05 167.8,8.05
R_SPK-_CN on BOTTOM (solid shape): 167.29,10.34 167.29,8.4 167.82,7.88 167.82,6.89 167.82,6.88 167.82,6.26 167.8,6.23 166.88,6.23 166.77,6.34 166.77,6.43 166.78,6.51 166.78,6.59 166.74,6.83 166.57,7 166.56,7 166.4,7.16 166.4,10.41 166.42,10.45 166.45,10.46 167.16,10.46
REGOUT on TOP (solid shape): 29,88.5 29,86.54 28.6,86.14 28.19,86.14 28.05,86.28 28.05,88.49 28.1,88.54 28.97,88.54
REGOUT on BOTTOM (solid shape): 28.99,87.04 28.99,86.16 28.86,86.03 28.86,86 28.86,85.98 28.83,85.95 28.83,84.47 28.73,84.38 27.92,84.38 27.84,84.39 27.72,84.5 27.72,87.04 27.85,87.17 28.86,87.17
RING2 on TOP (solid shape): 184.44,16.81 184.44,16.31 184.18,16.05 183.55,16.05 183.48,16.05 183.42,16.04 183.33,16.06 183.29,16.14 183.29,16.81 183.42,16.94 184.31,16.94
RING2 on TOP (solid shape): 170.46,48.35 170.46,46.71 170.26,46.51 170.04,46.51 170.02,46.52 169.8,46.63 169.56,46.66 169.48,46.69 169.45,46.76 169.45,48.29 169.53,48.37 170.45,48.37
RING2 on IN2 (solid shape): 183.17,18.21 183.17,17.32 183.55,16.94 183.67,16.94 183.8,16.81 183.8,16.05 183.67,15.92 182.2,15.92 182.16,15.94 182.15,15.97 182.15,18.21 182.28,18.34 183.04,18.34
RING2 on IN2 (solid shape): 170.97,47.42 170.97,46.4 170.98,46.33 170.98,45.46 170.97,45.37 170.99,45.28 170.99,44.95 170.98,44.93 170.97,44.91 170.85,44.63 170.97,44.34 170.98,44.33 170.99,44.31 170.99,43.65 170.69,43.36 170.69,40.44 170.54,40.28 169.6,40.28 169.45,40.44 169.45,44.48 169.72,44.75 169.74,44.75 170.01,44.9 170.08,45.2 169.95,45.55 169.58,45.62 169.49,45.64 169.45,45.72 169.45,47.65 169.55,47.75 170.64,47.75
RING2_R on TOP (solid shape): 170.4,50.48 170.72,50.48 170.81,50.48 170.9,50.5 170.93,50.49 171.09,50.32 171.09,49.2 171.09,48.91 170.94,48.75 169.62,48.75 169.4,48.97 169.4,50.51 169.44,50.56 170.31,50.56
RING2_R on IN1 (solid shape): outline of 128 points within 169.5,48.36 185.53,51.89
SLEEVE on TOP (solid shape): 185.71,18.21 185.71,17.96 185.58,17.83 184.69,17.83 184.44,17.58 184.44,17.32 184.31,17.19 183.67,17.19 183.29,17.58 183.29,17.83 183.42,17.96 184.06,17.96 184.44,18.34 185.58,18.34
SLEEVE on TOP (solid shape): 173.42,37.6 173.42,37.29 172.98,36.85 172.58,36.85 172.23,37.2 172.23,37.22 172,37.75 171.47,37.97 171.4,38 171.37,38.07 171.37,38.41 171.47,38.51 171.91,38.51 171.93,38.53 172.49,38.53
SLEEVE on IN2 (solid shape): outline of 150 points within 171.99,17.45 185.71,38.15
SLEEVE_R on TOP (solid shape): 171.88,39.91 171.88,39.02 171.75,38.89 171.31,38.89 170.99,38.56 170.99,37.04 170.9,36.96 170.63,36.96 169.94,37.64 169.59,37.64 169.51,37.64 169.43,37.63 169.41,37.63 169.38,37.64 169.36,37.67 169.36,39.81 169.55,40 171.79,40
TOUCH_SCREEN_PWR on TOP (solid shape): 167.04,81.08 167.04,80.69 166.91,80.57 166.91,76.88 166.72,76.69 166.57,76.69 166.02,77.24 166.02,80.69 166.08,80.88 166.07,81.08 166.09,81.16 166.17,81.2 166.91,81.2
TOUCH_SCREEN_PWR on BOTTOM (solid shape): 167.16,81.08 167.16,80.5 167.15,80.46 167.11,80.45 167.11,79.37 167.04,79.3 166.91,79.3 166.87,79.31 166.86,79.35 166.86,80.45 166.61,80.45 166.61,79.35 166.59,79.31 166.56,79.3 166.4,79.3 166.36,79.34 166.36,80.45 166.27,80.45 166.21,80.5 166.21,80.65 165.89,80.97 165.89,81.08 166.02,81.2 167.04,81.2
TPM_VDD on IN2 (solid shape): outline of 722 points within 37.12,46.28 46.01,55.29
UGATE_VCGI on BOTTOM (solid shape): 52.71,70.74 52.78,70.71 52.81,70.64 52.89,70.41 53.08,70.26 53.09,70.26 53.14,70.2 53.14,69.98 53.19,69.84 53.29,69.71 53.3,69.69 53.3,69.63 53.46,69.47 53.47,69.44 53.46,69.4 53.4,69.34 53.25,69.34 53.19,69.39 51.87,69.39 51.77,69.49 51.77,70.66 51.85,70.74
UGATE_VNN on TOP (solid shape): 40.06,69.47 40.06,68.86 40.03,68.78 39.95,68.75 39.75,68.72 39.6,68.6 39.58,68.58 39.56,68.58 39.02,68.58 38.79,68.35 38.51,68.35 38.36,68.5 38.36,69.44 38.44,69.52 40.01,69.52
USBPWR1 on TOP (solid shape): 85.63,95.1 85.63,93.01 85.88,92.76 88.12,92.76 88.27,92.61 89.08,92.61 89.19,92.51 89.19,91.06 89.41,90.83 89.41,89.84 89.29,89.71 84.66,89.71 84.58,89.8 84.58,90.54 83.93,91.18 83.93,94.84 84.31,95.22 85.5,95.22
USBPWR1 on BOTTOM (solid shape): outline of 197 points within 85.05,91.92 93,98.74
USBPWR2 on BOTTOM (solid shape): 171.05,58.85 171.05,58.82 170.91,58.68 170.91,58.2 170.95,58.15 170.95,57.96 170.91,57.91 170.91,57.44 171.05,57.3 171.05,56.89 171.3,56.64 172.75,56.64 173.72,57.61 174.28,57.61 174.53,57.35 174.53,55.77 174.43,55.68 167.8,55.68 167.67,55.8 167.67,56.18 167.8,56.56 167.67,56.95 167.67,58.85 167.8,58.98 170.92,58.98
USBPWR3 on TOP (solid shape): 112.12,94.28 112.68,94.28 112.81,94.16 112.81,93.27 112.68,93.14 110.78,93.14 110.67,93.24 110.67,94 111.26,94.59 111.82,94.59
USBPWR3 on BOTTOM (solid shape): 112.4,94.16 114.71,94.16 114.75,94.12 114.75,94.11 114.82,94.01 114.92,93.94 114.93,93.94 115.09,93.78 115.09,91.49 114.84,91.24 113.44,91.24 113.27,91.41 113.27,92.25 113.14,92.38 105.77,92.38 105.45,92.7 105.45,93.46 105.77,93.78 107.67,93.78 108.79,93.49 109.91,93.77 109.93,93.78 110.42,93.78 111.26,94.61 111.94,94.61
USBPWR3 on IN1 (solid shape): 112.55,94.36 112.55,93.22 111.41,92.07 108.52,92.07 107.5,91.06 103.69,91.06 103.52,91.23 103.5,91.25 103.5,91.28 103.51,91.32 103.51,91.36 103.51,91.42 103.49,91.5 103.49,91.57 103.54,91.62 104.05,91.62 104.06,91.63 104.21,91.63 105.09,92.51 105.09,92.88 105.91,93.7 107.83,93.7 108.79,93.49 109.76,93.69 109.77,93.7 110.04,93.7 110.8,94.46 112.45,94.46
VA on TOP (solid shape): 33.74,104.49 33.74,101.04 32.87,100.18 26.04,100.18 25.89,100.33 23.27,100.33 23.12,100.48 23.12,104.39 23.37,104.65 33.59,104.65
VA on BOTTOM (solid shape): 21.27,83.49 21.27,81.25 20.94,80.92 16.19,80.92 15.73,81.38 15.73,83.49 16.08,83.84 20.91,83.84
VA on SVCC (solid shape): outline of 229 points within 15.53,82.22 33.94,105.97
VA1 on BOTTOM (solid shape): 21.42,79.88 21.42,74.95 20.83,74.37 20.83,69.65 20.4,69.21 15.81,69.21 15.75,69.26 15.75,80.34 15.96,80.54 20.76,80.54
VA1 on IN2 (solid shape): 139.73,6.78 139.73,5.13 139.61,5 138.33,5 138.21,5.13 138.21,6.78 138.34,6.91 139.61,6.91
VA1 on IN2 (solid shape): outline of 109 points within 17.43,38.94 23.1,75
VA1 on IN2 (solid shape): outline of 258 points within 49.87,9.65 64.32,12.37
VA2 on BOTTOM (solid shape): 24.21,73.84 24.21,70.58 24.19,70.56 23.25,70.56 23.12,70.69 21.55,70.69 21.5,70.74 21.5,74.06 21.65,74.22 23.83,74.22
VRTC_3P3 on TOP (solid shape): 105.44,73.33 105.44,70.41 105.31,70.28 105.29,70.28 105.15,70.21 105.08,70.07 105.08,70.05 104.93,69.9 104.93,68.76 104.81,68.63 104.43,68.63 104.34,68.72 104.32,68.74 104.32,68.76 104.33,68.81 104.32,68.85 104.18,69.1 103.9,69.17 103.88,69.17 103.79,69.26 103.79,69.65 103.91,69.76 103.94,69.77 103.95,69.77 104.29,69.83 104.42,70.14 104.44,70.21 104.5,70.25 104.96,70.71 105.11,71.05 104.99,71.39 104.95,71.44 104.93,71.47 104.93,71.58 104.94,71.59 104.97,71.65 104.97,71.71 104.97,71.99 104.97,72.05 104.94,72.11 104.93,72.12 104.93,72.31 104.55,72.69 104.55,73.33 104.68,73.46 105.32,73.46
WLAN_VDD on TOP (solid shape): 19.88,22.05 20.07,21.99 20.27,22.05 20.49,22.05 20.71,21.98 20.92,22.05 22.82,22.05 22.99,21.87 22.99,20.39 22.89,20.29 21.44,20.29 21.04,20.7 20.12,20.7 19.74,21.08 19.74,21.92 19.87,22.05
N17894030 on IN1 (solid shape): 37.37,95.55 37.37,94.79 37.33,94.75 37.3,94.74 37.26,94.75 37.07,94.81 36.87,94.75 36.62,94.57 36.6,94.26 36.61,94.26 36.61,93.79 36.6,93.78 36.58,93.64 36.6,93.5 36.61,93.49 36.61,93.27 36.74,93.14 37.24,93.14 37.37,93.01 37.37,92 37.24,91.87 36.86,91.87 36.84,91.85 36.83,91.85 36.6,91.65 36.61,91.35 36.61,90.91 36.6,90.89 36.64,90.53 36.97,90.39 37.11,90.38 37.24,90.42 37.27,90.43 37.3,90.41 37.37,90.35 37.37,88.95 37.24,88.82 37.15,88.82 37.14,88.83 37.05,88.86 36.96,88.86 36.63,88.71 36.61,88.35 36.61,87.9 36.64,87.54 36.96,87.39 37.05,87.39 37.14,87.42 37.15,87.43 37.24,87.43 37.37,87.3 37.37,86.41 37.24,86.28 35.21,86.28 35.08,86.41 35.08,95.43 35.34,95.68 37.24,95.68
N25929013 on TOP (solid shape): 24.16,80.82 24.16,79.77 24.54,79.39 24.54,77.87 24.54,77.77 24.67,77.65 24.67,76.38 24.54,76.25 22.89,76.25 22.77,76.38 22.77,78.54 22.13,79.17 21.5,79.17 21.11,78.79 20.23,78.79 20.1,78.92 20.1,80.69 20.35,80.95 24.04,80.95
N30282349 on TOP (solid shape): 114.97,30.28 114.97,28.72 114.85,28.6 114.85,28 114.71,27.86 112.81,27.86 112.43,28.24 112.43,30.15 112.81,30.53 114.71,30.53
N30282349 on BOTTOM (solid shape): 113.46,30.39 113.46,29.62 113.13,29.29 113.03,29.29 112.89,29.15 112.89,27.39 112.85,27.35 112.69,27.35 112.66,27.38 112.66,29.16 112.61,29.21 112.61,30.4 112.69,30.48 113.36,30.48
N30318989 on TOP (solid shape): 147.23,74.59 147.24,74.57 147.23,74.56 147.34,74.2 147.69,74.1 147.7,74.1 147.73,74.09 149.89,74.09 150.02,73.96 150.02,72.69 149.89,72.57 144.05,72.57 143.92,72.69 143.92,75.05 143.94,75.09 143.97,75.11 146.72,75.11
N30318989 on BOTTOM (solid shape): 145.44,80.29 145.46,80.29 145.56,80.2 145.56,79.51 145.57,79.51 145.57,79.42 145.7,79.3 145.96,79.3 146.08,79.17 146.08,76.47 146.07,76.44 146.06,76.43 146.03,76.42 145.68,76.42 145.67,76.32 145.66,76.3 145.56,76.29 145.56,75.51 145.66,75.5 145.67,75.48 145.68,75.38 146.19,75.38 146.2,75.41 146.21,75.43 146.23,75.43 146.25,75.43 146.34,75.36 146.59,75.36 146.72,75.23 146.72,74.85 146.59,74.73 146.34,74.73 146.21,74.6 146.21,71.8 146.08,71.68 144.05,71.68 143.92,71.8 143.92,75.11 144.05,75.23 144.56,75.23 144.69,75.36 144.69,75.48 144.71,75.5 145.31,75.51 145.31,76.29 145.06,76.29 145.06,75.51 144.81,75.51 144.81,76.29 144.71,76.3 144.69,76.32 144.69,76.35 144.69,79.17 144.81,79.3 145.19,79.3 145.32,79.42 145.32,80.19
N30318999 on BOTTOM (solid shape): 134.27,80.57 134.27,77.27 134.14,77.14 127.67,77.14 127.54,77.01 127.54,75.49 127.41,75.36 126.4,75.36 126.27,75.49 126.27,79.42 126.02,79.68 124.82,79.68 124.75,79.68 124.62,79.81 124.62,79.88 125.31,80.57 132.24,80.57 132.37,80.69 134.14,80.69
N30322034 on TOP (solid shape): 115.75,15.92 115.83,15.92 115.87,15.91 115.88,15.87 115.88,15.78 119.74,15.78 119.78,15.76 119.79,15.72 119.79,14.3 119.69,14.2 119.64,14.2 119.63,14.21 119.4,14.27 119.18,14.2 119.01,14.2 118.76,14.27 118.52,14.18 118.46,14.15 118.39,14.18 118.02,14.25 117.77,13.96 117.9,13.6 118.28,13.54 118.38,13.53 118.42,13.44 118.42,13.4 118.42,13.39 118.4,13.26 118.42,13.13 118.42,13.12 118.42,11.91 118.24,11.73 114.46,11.73 114.33,11.86 114.33,15.42 114.34,15.43 114.34,15.81 114.48,15.95 115.73,15.95
N30322038 on TOP (solid shape): 109.39,14.41 109.43,14.43 109.46,14.41 109.48,14.4 110.85,14.4 110.89,14.38 110.9,14.35 110.9,11.61 111.16,11.35 111.16,10.97 111.03,10.84 109.89,10.84 109.76,10.97 109.76,12.75 109,13.51 109,14.02
N30404082 on BOTTOM (solid shape): 128.81,73.35 128.81,66.85 128.3,66.34 126.75,66.34 126.72,66.36 126.7,66.39 126.7,66.54 123.02,66.54 122.97,66.6 122.97,71.4 122.99,71.44 123.01,71.45 123.2,71.78 123.01,72.11 122.99,72.12 122.97,72.16 122.97,72.67 122.82,72.82 122.49,72.82 122.46,72.85 122.46,73.01 122.36,73.1 122.36,73.25 122.43,73.33 123.28,73.33 123.3,73.33 123.37,73.4 128.76,73.4
N30404100 on BOTTOM (solid shape): 138.46,70.93 138.46,68.63 138.59,68.5 139.61,68.5 139.73,68.38 139.73,64.06 139.48,63.8 137.19,63.8 136.94,64.06 136.94,67.36 136.68,67.61 136.68,69.52 136.94,69.77 136.94,70.63 136.95,70.66 136.99,70.68 137.65,70.68 137.65,70.92 136.99,70.92 136.95,70.94 136.94,70.97 136.94,71.13 136.95,71.16 136.99,71.18 137.65,71.18 137.65,71.24 137.67,71.28 137.7,71.3 138.09,71.3
N30417403 on TOP (solid shape): 125.13,17.7 125.13,14.15 125,14.02 122.71,14.02 122.59,14.15 122.59,17.7 122.71,17.83 125,17.83
