# Allegro board Quanta ZHE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQSN0: length 61.2
  IN1 w0.102: v1(68.47,48.14) 68.21,47.88 67.95,47.88 67.65,47.57 67.65,41.14 62.8,36.29 61.58,36.29 59.95,34.67 57.26,34.67 53.17,30.58 53.17,29.51 50.53,26.86 50.53,25.71 50.79,25.45 50.97,25.45 v1(51.32,25.1)
  BOTTOM w0.089: U22.AT55 85.93,59.18 85.72,59.18 85.64,59.1 84.16,59.1 83.78,58.72 81.97,58.72 81.62,58.37 80.71,58.37 79.88,57.54 79.85,57.54 79.83,57.52
  BOTTOM w0.127: 79.83,57.52 78.01,55.71 76.19,55.71 71.74,51.26 69.65,51.26 69.31,50.91 69.31,48.21 68.97,47.88 68.73,47.88 v1(68.47,48.14) ; JDIM1.11 49.78,27.37 49.92,27.22 49.92,26.99 50.16,26.75 50.16,26.02 50.88,25.3 51.12,25.3 v1(51.32,25.1)
M_A_DQSN1: length 51.3
  IN3 w0.089: 84.15,55.66 84.17,55.66 84.21,55.63 84.7,55.63 87.07,58 88.33,58 88.53,57.81 88.53,57.65 v1(88.75,57.43)
  IN3 w0.127: 84.15,55.66 83.88,55.66 81.11,52.89 81.11,50.98 79.28,49.15 79.28,43.62 76.13,40.46 76.13,39.29 67.82,30.99 67.82,25.57 68.38,25.01 68.38,23.8 68.15,23.57 67.93,23.57 v1(67.74,23.75)
  BOTTOM w0.089: v1(88.75,57.43) 89.1,57.79 U22.AW48
  BOTTOM w0.127: JDIM1.74 65.53,20.97 65.67,21.11 65.67,21.31 66.06,21.7 66.41,21.7 66.88,22.17 66.88,23.12 67.3,23.54 67.53,23.54 v1(67.74,23.75)
M_A_DQSN2: length 49.3
  IN1 w0.102: v1(62.27,25.04) 62.09,25.22 61.76,25.22 61.3,25.68 61.3,26.61 70.34,35.65 70.34,36.64 74.55,40.86 74.55,46.32 74.94,46.7 75.3,46.7 v1(75.46,46.87)
  BOTTOM w0.089: 81.85,53.06 81.87,53.07 81.9,53.07 82.89,54.06 82.89,54.33 84.28,55.72 84.85,55.72 85.29,56.17 86.02,56.17 86.09,56.19 86.15,56.23 86.21,56.27 U22.BB53
  BOTTOM w0.127: 81.85,53.06 78.09,49.3 76.77,49.3 76.16,48.68 76.16,46.97 75.86,46.67 75.66,46.67 v1(75.46,46.87) ; JDIM1.53 60.27,26.92 60.56,26.63 60.87,26.63 61.24,26.27 61.24,25.82 61.78,25.27 62.04,25.27 v1(62.27,25.04)
M_A_DQSN3: length 64.5
  IN3 w0.089: 83.8,59.1 83.82,59.1 83.86,59.14 84.25,59.14 84.46,58.93 85.31,58.93 86.89,60.5 89.14,60.5 89.76,59.87 90.96,59.87 91.14,59.69 91.14,59.49 90.99,59.34 v1(90.88,59.34)
  IN3 w0.127: v1(57,24.21) 57,23.62 56.9,23.52 56.77,23.52 56.45,23.85 56.45,25.58 60.13,29.26 60.13,31.04 65.01,35.91 65.01,37.22 72.63,44.84 72.63,51.52 80.21,59.1 83.8,59.1
  BOTTOM w0.089: U22.AR43 91.23,59.55 91.02,59.34 v1(90.88,59.34)
  BOTTOM w0.127: v1(57,24.21) 57,24.03 55.18,22.21 55.18,21.14 55.03,20.98 JDIM1.32
M_A_DQSN4: length 42.1
  IN3 w0.089: 93.87,50.71 93.87,50.73 93.83,50.77 93.83,52.14 93.69,52.29 93.69,54.37 93.83,54.52 93.83,56.46 94.29,56.91 94.29,58.31 94.65,58.67 v1(94.98,58.67)
  IN3 w0.127: v1(92.83,25.74) 92.83,25.36 92.67,25.2 92.47,25.2 92.31,25.35 92.31,26.8 94.9,29.4 94.9,32.84 95.56,33.5 95.56,46.3 93.87,47.99 93.87,50.71
  BOTTOM w0.089: U22.AV35 94.62,58.32 v1(94.98,58.67)
  BOTTOM w0.127: JDIM1.177 93.28,27.25 93.38,27.14 93.38,25.16 93.27,25.05 92.96,25.05 92.83,25.18 v1(92.83,25.74)
M_A_DQSN5: length 40.7
  IN1 w0.102: v1(90.41,42.94) 90.13,43.23 89.95,43.23 89.84,43.12 89.84,35.59 94.09,31.34 94.09,30.73 97.47,27.34 97.47,23.57 v1(96.6,22.7)
  BOTTOM w0.089: U22.BJ38 93.48,52.52 93.53,52.43 93.53,51.41 93.21,51.08 93.21,50.84 93.23,50.82 93.23,50.8
  BOTTOM w0.127: v1(90.41,42.94) 90.67,43.2 90.88,43.2 91.14,43.46 91.14,45.72 92.74,47.32 92.74,49.43 93.23,49.92 93.23,50.8 ; JDIM1.198 98.53,20.92 98.67,21.06 98.67,21.23 97.47,22.43 97.47,22.58 96.91,23.14 96.75,23.14 96.6,22.99 v1(96.6,22.7)
M_A_DQSN6: length 36.2
  IN3 w0.089: 98.41,50.16 98.37,50.2 98.37,51.2 96.49,53.08 96.49,54.1 96.4,54.19 96.4,54.86 96.14,55.12 v1(95.93,55.12)
  IN3 w0.127: 98.41,50.16 98.41,49.42 101.8,46.03 101.8,26.79 102.58,26.01 102.78,26.01 v1(102.97,26.2)
  BOTTOM w0.089: v1(95.93,55.12) 96.29,55.47 U22.BD31
  BOTTOM w0.127: JDIM1.219 103.78,27.37 103.92,27.22 103.92,26.97 103.71,26.76 103.71,26.21 103.46,25.97 103.2,25.97 v1(102.97,26.2)
M_A_DQSN7: length 42.3
  IN1 w0.102: v1(96.09,43) 96.37,42.73 96.67,42.73 96.96,42.43 96.96,38.37 99.18,36.15 99.87,36.15 104.14,31.88 104.14,30.55 108.77,25.92 108.77,23.7 109.15,23.32 109.38,23.32 109.48,23.42 v1(109.48,23.94)
  BOTTOM w0.089: U22.BK31 96.43,52.14 96.61,51.96 96.61,51.96 96.61,51.02 96.2,50.61 96.2,50.13 96.22,50.11 96.22,50.09
  BOTTOM w0.127: v1(109.48,23.94) 109.48,23.59 109.3,23.42 108.99,23.42 108.59,23.01 108.59,21.93 109.15,21.37 109.15,21.11 109.03,20.98 JDIM1.240 ; v1(96.09,43) 95.82,42.72 95.68,42.72 95.56,42.84 95.56,44 96.22,44.66 96.22,50.09
M_A_DQSN8: length 7.2
  TOP w0.127: R305.2 70.78,27.46 70.78,25.95 v1(71.72,25.01)
  BOTTOM w0.102: JDIM1.95 70.78,27.27 70.92,27.12 70.92,25.92 71.27,25.58 71.58,25.58 71.72,25.44 v1(71.72,25.01)
M_A_DQSP0: length 61.2
  IN1 w0.102: v1(51.35,26) 51.02,25.68 50.88,25.68 50.76,25.8 50.76,26.77 53.4,29.41 53.4,30.49 57.35,34.44 60.05,34.44 61.67,36.07 62.9,36.07 67.88,41.04 67.88,47.48 68.05,47.65 68.2,47.65 v1(68.47,47.38)
  BOTTOM w0.089: U22.AT53 86.46,59.14 86.21,58.98 86.05,58.87 85.85,58.87 85.79,58.94 84.24,58.94 84.04,58.74 84.04,58.74 83.85,58.55 82.05,58.55 81.69,58.19 80.78,58.19 80.01,57.41 80.01,57.38 79.99,57.36
  BOTTOM w0.127: v1(51.35,26) 51.35,25.63 51.24,25.53 50.97,25.53 50.39,26.11 50.39,26.85 50.15,27.09 50.15,27.26 50.27,27.38 JDIM1.13 ; 79.99,57.36 78.11,55.48 76.28,55.48 71.84,51.03 69.75,51.03 69.54,50.82 69.54,48.11 69.07,47.65 68.74,47.65 v1(68.47,47.38)
M_A_DQSP1: length 51.3
  IN3 w0.089: 84.15,55.41 84.17,55.41 84.21,55.45 84.77,55.45 87.15,57.82 88.26,57.82 88.35,57.73 88.35,57.5 88.28,57.43 v1(88.03,57.43)
  IN3 w0.127: 84.15,55.41 83.99,55.41 81.36,52.78 81.36,50.87 79.53,49.05 79.53,43.51 76.38,40.36 76.38,39.19 68.08,30.88 68.08,25.68 68.64,25.12 68.64,23.7 68.26,23.32 67.82,23.32 67.74,23.23 v1(67.74,22.99)
  BOTTOM w0.089: v1(88.03,57.43) 88.2,57.43 88.39,57.62 U22.AW49
  BOTTOM w0.127: JDIM1.76 66.03,20.99 65.9,21.11 65.9,21.22 66.15,21.47 66.51,21.47 67.11,22.07 67.11,23.02 67.4,23.32 67.65,23.32 67.74,23.22 v1(67.74,22.99)
M_A_DQSP2: length 49.2
  IN1 w0.102: v1(75.46,46.11) 75.46,46.38 75.37,46.48 75.03,46.48 74.78,46.22 74.78,40.76 70.57,36.55 70.57,35.56 61.53,26.52 61.53,25.78 61.86,25.45 62.16,25.45 62.27,25.56 v1(62.27,25.93)
  BOTTOM w0.089: U22.BC54 85.36,55.99 85.17,55.8 84.93,55.55 84.37,55.55 83.06,54.25 83.06,53.99 82.03,52.95 82.03,52.91 82.01,52.9
  BOTTOM w0.127: 82.01,52.9 78.19,49.07 76.87,49.07 76.38,48.59 76.38,46.88 75.95,46.45 75.59,46.45 75.46,46.32 v1(75.46,46.11) ; v1(62.27,25.93) 62.47,25.74 62.47,25.6 62.36,25.5 61.87,25.5 61.46,25.91 61.46,26.36 60.97,26.86 60.66,26.86 60.5,27.01 60.5,27.15 60.78,27.43 JDIM1.55
M_A_DQSP3: length 64.5
  IN3 w0.089: 83.8,59.36 83.82,59.36 83.86,59.32 84.32,59.32 84.54,59.1 85.24,59.1 86.81,60.68 89.22,60.68 89.84,60.05 90.42,60.05 90.42,60.05 91.03,60.05 91.32,59.76 91.32,59.61 v1(91.59,59.34)
  IN3 w0.127: 83.8,59.36 80.11,59.36 72.38,51.63 72.38,44.95 64.75,37.32 64.75,36.02 59.87,31.14 59.87,29.36 56.19,25.68 56.19,23.74 v1(57,22.94)
  BOTTOM w0.089: v1(91.59,59.34) 91.95,59.7 U22.AR41
  BOTTOM w0.127: JDIM1.34 55.53,21.04 55.41,21.16 55.41,22.12 56.61,23.32 56.83,23.32 57,23.14 v1(57,22.94)
M_A_DQSP4: length 42.1
  IN3 w0.089: v1(93.47,58.67) 94.11,58.03 94.11,56.99 93.66,56.54 93.66,54.59 93.51,54.45 93.51,52.22 93.66,52.07 93.66,50.77 93.62,50.73 93.62,50.71
  IN3 w0.127: 93.62,50.71 93.62,47.89 95.31,46.2 95.31,33.61 94.65,32.95 94.65,29.5 92.06,26.91 92.06,25.25 v1(92.83,24.47)
  BOTTOM w0.089: U22.AV37 93.82,58.32 v1(93.47,58.67)
  BOTTOM w0.127: v1(92.83,24.47) 92.83,24.7 92.95,24.82 93.37,24.82 93.61,25.06 93.61,27.13 93.78,27.29 JDIM1.179
M_A_DQSP5: length 40.7
  IN1 w0.102: v1(96.6,23.97) 96.6,23.39 96.7,23.29 96.87,23.29 97.24,23.67 97.24,27.25 93.86,30.63 93.86,31.25 89.61,35.49 89.61,43.22 89.85,43.46 90.17,43.46 v1(90.41,43.7)
  BOTTOM w0.089: U22.BL38 93.35,52.26 93.35,51.48 93.03,51.16 93.03,50.84 93,50.82 93,50.8
  BOTTOM w0.127: 93,50.8 93,50.02 92.51,49.53 92.51,47.42 90.91,45.82 90.91,43.56 90.79,43.43 90.68,43.43 v1(90.41,43.7) ; v1(96.6,23.97) 96.6,23.49 96.73,23.36 97,23.36 97.7,22.67 97.7,22.52 98.89,21.32 98.89,21.07 99.03,20.94 JDIM1.200
M_A_DQSP6: length 36.2
  IN3 w0.089: v1(95.93,54.41) 96.31,54.02 96.31,53 98.19,51.13 98.19,50.2 98.15,50.16
  IN3 w0.127: v1(102.97,25.49) 102.97,25.61 102.83,25.75 102.47,25.75 101.54,26.68 101.54,45.92 98.15,49.31 98.15,50.16
  BOTTOM w0.089: U22.BF31 96.29,54.76 v1(95.93,54.41)
  BOTTOM w0.127: JDIM1.221 104.28,27.36 104.15,27.23 104.15,26.88 103.94,26.66 103.94,26.12 103.56,25.74 103.21,25.74 v1(102.97,25.49)
M_A_DQSP7: length 42.3
  IN1 w0.102: v1(96.09,42.24) 96.36,42.5 96.57,42.5 96.73,42.34 96.73,38.28 99.09,35.92 99.78,35.92 103.91,31.79 103.91,30.46 108.54,25.83 108.54,23.61 v1(109.48,22.67)
  BOTTOM w0.089: U22.BJ32 96.11,52.83 96.11,52.6 96.17,52.53 96.23,52.45 96.25,52.43 96.25,52.06 96.43,51.88 96.43,51.1 96.02,50.69 96.02,50.13 95.99,50.11 95.99,50.09
  BOTTOM w0.127: v1(96.09,42.24) 95.84,42.49 95.59,42.49 95.33,42.75 95.33,44.09 95.99,44.75 95.99,50.09 ; JDIM1.242 109.53,20.98 109.38,21.13 109.38,21.46 108.81,22.03 108.81,22.91 109.09,23.19 109.3,23.19 109.48,23.02 v1(109.48,22.67)
M_A_DQSP8: length 7
  TOP w0.127: v1(71.74,26.28) 71.74,25.74 71.61,25.6 71.45,25.6 71.01,26.04 71.01,27.46 R306.2
  BOTTOM w0.102: JDIM1.97 71.28,27.27 71.13,27.12 71.13,26.01 71.36,25.78 71.63,25.78 71.74,25.89 v1(71.74,26.28)
M_A_DRAMRST#: length 72.1
  TOP w0.14: v1(68.5,44.68) 70.2,44.68 70.82,45.3 70.82,45.3 72.97,47.45 72.97,47.98 73.96,48.98 78,48.98 80.13,51.1 C187.1 R196.1 ; C280.2 73.82,21.18 v1(73.65,21.35) 74.36,22.06 R625.2
  IN3 w0.127: v1(73.65,21.35) 73.21,20.91 60.98,20.91 60.33,21.56 54.22,21.56 53.91,21.87 53.91,25.47 53.37,26.01 53.37,27.6 55.68,29.91 55.68,30.83 61.41,36.56 61.41,37.61 68.49,44.68 v1(68.5,44.68)
  BOTTOM w0.203: v1(73.65,21.35) 74.02,20.98 JDIM1.108
M_A_EVENT#: length 2.2
  TOP w0.14: R332.2 v1(80.42,18.78)
  BOTTOM w0.14: JDIM1.134 80.53,18.88 v1(80.42,18.78)
M_A_ODT0_DIMM: length 43.9
  IN3 w0.089: 91.09,49.71 91.57,50.19 91.57,51.21 91.17,51.62 91.17,53.8 91.45,54.07 91.75,54.07 91.95,54.28 91.95,55.25 v1(92.52,55.82)
  IN3 w0.178: 91.09,49.71 90.91,49.53 90.91,45.94 89.94,44.97 89.94,41.73 90.12,41.55 90.81,41.55 90.99,41.37 90.99,41.02 90.81,40.84 90.12,40.84 89.94,40.66 89.94,40.3 90.12,40.13 90.81,40.13 90.99,39.95 90.99,39.59 90.81,39.42 90.12,39.42 89.94,39.24 89.94,38.88 90.12,38.7 90.81,38.7 90.99,38.53 90.99,38.17 90.81,37.99 90.12,37.99 89.94,37.82 89.94,37.46 90.12,37.28 90.81,37.28 90.99,37.1 90.99,36.75 90.81,36.57 90.12,36.57 89.94,36.39 89.94,36.04 90.12,35.86 90.81,35.86 90.99,35.68 90.99,35.33 90.81,35.15 90.12,35.15 89.94,34.97 89.94,28.69 88.53,27.28 v1(88.53,25.83)
  BOTTOM w0.089: v1(92.52,55.82) 92.86,55.47 U22.BD39
  BOTTOM w0.203: JDIM1.155 87.78,27.16 88.53,26.41 v1(88.53,25.83)
M_A_ODT1_DIMM: length 43.9
  IN3 w0.089: v1(92.52,55.11) 92.13,54.72 92.13,54.15 92,54.02 92,53.31 91.73,53.04 91.73,51.36 91.85,51.23 91.85,49.93 91.36,49.44 91.38,49.41
  IN3 w0.178: 91.38,49.41 91.38,39.67 91.56,39.49 92.23,39.49 92.41,39.32 92.41,38.96 92.23,38.78 91.55,38.78 91.37,38.61 91.37,38.25 91.55,38.07 92.23,38.07 92.41,37.89 92.41,37.54 92.23,37.36 91.55,37.36 91.37,37.18 91.37,36.83 91.55,36.65 92.23,36.65 92.41,36.47 92.41,36.12 92.23,35.94 91.56,35.94 91.38,35.76 91.38,35.41 91.56,35.23 92.23,35.23 92.41,35.05 92.41,34.69 92.23,34.52 90.65,34.52 90.44,34.31 90.44,33.96 90.6,33.81 92.23,33.81 92.41,33.63 92.41,33.27 92.23,33.09 90.65,33.09 90.44,32.89 90.44,31.15 91.01,30.58 91.01,29.03 89.44,27.46 89.44,26.69 v1(89.69,26.44)
  BOTTOM w0.089: U22.BF39 92.86,54.76 v1(92.52,55.11)
  BOTTOM w0.203: v1(89.69,26.44) 89.28,26.86 JDIM1.161
M_A_PARITY: length 2.5
  TOP w0.14: v1(83.08,29.56) 83.08,29.33 82.71,28.95 R309.2
  BOTTOM w0.14: v1(83.08,29.56) 83.08,29.35 82.78,29.05 JDIM1.143
M_A_RAS#: length 43.2
  IN3 w0.089: 90.56,52.7 90.22,53.04 90.22,53.86 90.37,54.01 90.78,54.01 91.09,54.32 91.09,54.65 91.55,55.11 v1(91.55,55.12)
  IN3 w0.178: v1(87.42,23.31) 87.13,23.31 86.89,23.55 86.89,30.54 87.75,31.39 87.75,33.95 87.92,34.11 88.86,34.11 89.03,34.28 89.03,34.63 88.85,34.8 87.99,34.8 87.81,34.98 87.81,35.34 87.99,35.52 88.85,35.52 89,35.67 89,36.02 88.8,36.23 87.99,36.23 87.81,36.4 87.81,36.76 87.99,36.94 88.85,36.94 89.03,37.12 89.03,45.34 90,46.31 90,50.16 90.56,50.72 90.56,52.7
  BOTTOM w0.089: v1(91.55,55.12) 91.91,55.47 U22.BD41
  BOTTOM w0.203: JDIM1.152 87.02,21.76 87.42,22.15 v1(87.42,23.31)
M_A_WE#: length 41.8
  IN1 w0.127: v1(83.78,26.16) 84.16,26.54 84.16,33.71 84.03,33.84 83.19,33.84 83.06,33.97 83.06,34.22 83.19,34.35 84.03,34.35 84.16,34.47 84.16,34.73 84.03,34.86 83.19,34.86 83.06,34.98 83.06,35.24 83.19,35.36 84.03,35.36 84.16,35.49 84.16,35.74 84.03,35.87 83.19,35.87 83.06,36 83.06,36.25 83.19,36.38 84.03,36.38 84.16,36.51 84.16,36.76 84.03,36.89 83.19,36.89 83.06,37.01 83.06,37.27 83.19,37.4 84.03,37.4 84.16,37.52 84.16,43.71 v1(83.67,44.19)
  BOTTOM w0.089: 87.32,50.29 88.02,50.99 88.02,51.54 88.17,51.7 88.23,51.76 88.23,51.95 88.49,52.21 88.49,52.54 U22.BJ48
  BOTTOM w0.203: 87.32,50.29 84.18,47.15 84.18,44.6 83.78,44.19 v1(83.67,44.19) ; JDIM1.151 86.78,26.82 85.81,25.86 84.08,25.86 v1(83.78,26.16)
M_B1_ZQ0: length 3.8
  TOP w0.203: R145.1 135.58,61.29 v1(135.58,59.84) U9.F9
M_B2_ZQ0: length 10.7
  TOP w0.127: R193.1 v1(127.92,51.36)
  BOTTOM w0.14: v1(127.92,51.36) 128.05,51.48 128.68,51.48 130.33,49.83 134.66,49.83 135.36,50.53 135.36,51.69 U25.F9
M_B3_ZQ0: length 4.7
  TOP w0.14: R243.1 132.87,43.76 v1(133.53,43.1) 133.53,42.95 134.86,41.63 134.86,41.07 135.4,40.53 U13.F9
M_B4_ZQ0: length 3.6
  BOTTOM w0.14: U30.F9 135.62,34.09 v1(135.62,31.67) 135.62,30.97 R556.1
M_B_A0: length 87.7
  TOP w0.127: v1(143.81,55.4) 143.81,54.7 143.54,54.43 142.83,54.43 141.98,53.58 U9.P3 ; v1(143.55,37.58) 143.42,37.45 143.42,36.74 143,36.32 142.56,36.32 141.98,35.74 U13.P3
  TOP w0.203: R228.2 146.6,45.48 v1(146.26,45.82)
  IN1 w0.089: v1(105.9,53.62) 105.9,53.44 107.51,51.84 107.51,51.23 107.75,50.99
  IN1 w0.127: v1(146.26,45.82) 144.58,45.82 144.49,45.91 143.01,45.91 142.44,45.34 141.83,45.34 140.55,46.62 136.65,46.62 135.73,45.71 135.73,45.01 135.38,44.66 131.74,44.66 130.79,43.71 121.06,43.71 120.73,44.04 120.4,44.04 120.07,43.71 119.87,43.71 119.72,43.86 119.72,44.06 120.11,44.45 120.11,44.66 119.96,44.81 119.75,44.81 119.08,44.13 118.87,44.13 118.72,44.28 118.72,44.49 119.39,45.17 119.39,45.38 119.24,45.52 119.03,45.52 118.35,44.84 118.14,44.84 117.99,44.99 117.99,45.2 118.67,45.88 118.67,46.09 118.52,46.24 118.31,46.24 117.7,45.63 117.34,45.63 114.45,48.52 110.21,48.52 107.75,50.99
  IN3 w0.178: v1(143.55,37.58) 143.55,38.06 145.57,40.08 145.57,40.61 145.71,40.75 146.04,40.75 146.18,40.89 146.18,41.14 146.05,41.27 145.65,41.27 145.5,41.42 145.5,41.64 145.65,41.8 145.98,41.8 146.13,41.96 146.13,44.88 146.06,44.96 146.06,45.62 v1(146.26,45.82) 146.13,45.95 146.13,50.9 145.6,51.43 145.6,52.45 143.8,54.25 143.8,55.39 v1(143.81,55.4)
  BOTTOM w0.089: v1(105.9,53.62) 105.91,53.62 106.23,53.94 U22.BH9
  BOTTOM w0.127: v1(143.55,37.58) 143.41,37.44 143.29,37.44 143.14,37.59 143.14,37.95 142.91,38.17 142.37,38.17 141.89,38.66 141.89,38.84 U30.P3 ; U25.P3 141.84,56.57 141.84,56.28 142.17,55.95 142.98,55.95 143.24,55.7 143.24,55.45 143.39,55.29 143.7,55.29 v1(143.81,55.4)
M_B_A1: length 91.9
  TOP w0.127: U9.P7 141.98,56.55 142.45,56.08 142.91,56.08 143.17,55.82 143.98,55.82 144.24,55.56 v1(144.24,54.87) ; v1(143.91,36.78) 144,36.86 144,37.77 143.73,38.04 143.17,38.04 142.91,38.3 142.5,38.3 141.98,38.82 U13.P7
  TOP w0.203: v1(146.58,44.4) 146.93,44.75 148.05,44.75 R239.2
  IN1 w0.089: 107.51,50.69 107.32,50.69 106.65,51.37 106.65,52.29 105.51,53.42 105.51,55.27 v1(104.95,55.83)
  IN1 w0.127: v1(146.58,44.4) 146.58,44.42 146.79,44.64 146.79,45.08 146.54,45.34 144.43,45.34 143.76,44.67 141.15,44.67 140.83,44.99 140.83,45.5 140.08,46.24 136.8,46.24 136.11,45.55 136.11,44.85 135.54,44.28 131.9,44.28 130.95,43.33 119.11,43.33 114.29,48.14 110.06,48.14 107.51,50.69
  IN3 w0.178: v1(143.91,36.78) 143.91,35.76 144.06,35.61 144.28,35.61 144.43,35.76 144.43,36.93 144.01,37.35 144.01,38.03 146.58,40.6 v1(146.58,44.4) 146.58,44.42 146.7,44.55 146.7,46.14 146.46,46.38 146.46,51.03 145.92,51.57 145.92,52.61 144.24,54.29 v1(144.24,54.87)
  BOTTOM w0.089: U22.BC13 v1(104.95,55.83)
  BOTTOM w0.127: U30.P7 141.98,35.9 142.13,36.05 142.29,36.05 142.71,36.47 143.14,36.47 143.44,36.76 143.44,36.98 143.63,37.17 143.73,37.17 143.85,37.28 144.05,37.28 144.15,37.18 144.15,37.01 v1(143.91,36.78) ; U25.P7 141.98,53.58 142.81,54.41 144.38,54.41 144.51,54.53 144.51,54.74 144.38,54.87 v1(144.24,54.87)
M_B_A2: length 91.8
  TOP w0.127: U9.R3 143.14,53.87 144.81,53.87 145.6,54.66 v1(145.6,55.42) ; v1(145.34,37.58) 145.34,37.16 145.3,37.12 145.3,36.71 144.69,36.09 143.46,36.09 143.09,35.73 U13.R3
  TOP w0.203: R240.2 148.88,44.79 v1(147.77,45.9)
  IN1 w0.089: 108.79,51.66 108.22,52.23 108.05,52.23 107.5,52.78 107.1,52.78 106.47,53.41 106.47,54.1 106.41,54.15 106.41,54.7 106.08,55.03 v1(105.9,55.03)
  IN1 w0.127: 108.79,51.66 108.79,51.13 110.64,49.29 116.56,49.29 121.37,44.47 129.16,44.47 131.31,46.62 135.5,46.62 136.26,47.38 140.86,47.38 141.74,46.51 144.53,46.51 144.81,46.23 146.01,46.23 146.23,46.45 146.23,47.6 146.38,47.75 146.59,47.75 146.74,47.6 146.74,46.08 146.92,45.9 v1(147.77,45.9)
  IN3 w0.178: v1(145.6,55.42) 145.58,55.4 145.58,54.5 147.86,52.22 147.86,50.87 148.16,50.57 148.16,46.29 v1(147.77,45.9) 147.77,45.5 147.93,45.34 148.16,45.34 148.32,45.18 148.32,44.96 148.16,44.81 147.93,44.81 147.77,44.65 147.77,44.43 147.93,44.27 148.16,44.27 148.32,44.12 148.32,43.9 148.16,43.74 147.93,43.74 147.77,43.58 147.77,40.4 145.34,37.97 v1(145.34,37.58)
  BOTTOM w0.089: U22.BD11 v1(105.9,55.03)
  BOTTOM w0.127: U25.R3 142.78,56.94 142.89,57.06 143.07,57.06 143.21,56.92 143.21,56.59 143.63,56.17 144.98,56.17 145.6,55.55 v1(145.6,55.42) ; U30.R3 142.78,39.22 142.88,39.32 143.11,39.32 143.21,39.22 143.21,38.81 143.63,38.39 144.54,38.39 v1(145.34,37.58)
M_B_A3: length 89.3
  TOP w0.127: U9.N7 141.18,56.54 142.32,55.4 142.32,54.94 v1(142.27,54.9) ; U13.N7 141.18,38.76 141.7,38.24 141.84,38.24 142.22,37.85 142.22,36.9 v1(142.03,36.71)
  TOP w0.203: R252.2 145.05,44.18 v1(144.8,44.43)
  IN1 w0.089: v1(104.95,55.12) 105.34,54.73 105.34,53.29 106.36,52.27 106.36,51.3 108.08,49.58
  IN1 w0.127: v1(144.8,44.43) 144.21,44.43 144.17,44.39 144.17,42.98 144.01,42.82 143.81,42.82 143.66,42.98 143.66,44.08 143.45,44.29 142.08,44.29 141.96,44.16 141.96,42.98 141.8,42.82 141.6,42.82 141.45,42.98 141.45,44.16 141.32,44.29 140.83,44.29 140.44,44.68 140.44,45.34 139.92,45.86 136.96,45.86 136.49,45.39 136.49,44.7 135.7,43.9 132.06,43.9 131.11,42.95 118.95,42.95 114.14,47.76 109.9,47.76 108.11,49.55 108.08,49.58
  IN3 w0.178: v1(142.27,54.9) 142.27,54.38 144.53,52.12 144.53,49.93 145.04,49.43 145.04,47.12 144.8,46.87 v1(144.8,44.43) 144.8,42.43 144,41.63 144,39.83 142.21,38.03 142.21,37.33 142.53,37.01 142.53,35.61 142.4,35.48 142.18,35.48 142.03,35.63 v1(142.03,36.71)
  BOTTOM w0.089: U22.BD13 v1(104.95,55.12)
  BOTTOM w0.127: v1(142.27,54.9) 142.27,54.74 141.89,54.35 141.28,54.35 141.05,54.13 141.05,53.64 U25.N7 ; U30.N7 141.18,35.84 141.59,36.24 141.59,36.9 141.97,37.28 142.15,37.28 142.3,37.13 142.3,36.97 v1(142.03,36.71)
M_B_A4: length 89.9
  TOP w0.127: v1(141.78,55.3) 141.8,55.27 141.8,54.55 141.18,53.92 U9.N3 ; U13.N3 141.18,35.74 141.61,36.17 141.61,37.13 141.76,37.28 v1(141.76,37.72)
  TOP w0.203: v1(144.6,48.41) R210.2
  IN3 w0.178: v1(141.78,55.3) 141.83,55.25 141.83,54.36 143.59,52.6 143.59,49.69 143.72,49.56 144.45,49.56 144.63,49.38 144.63,49.16 144.5,49.03 143.72,49.03 143.59,48.9 143.59,47.62 143.75,47.47 143.97,47.47 144.13,47.62 144.13,48.28 144.25,48.41 v1(144.6,48.41) 144.6,47.18 144.41,46.99 144.41,45.01 144.3,44.91 144.3,42.42 143.72,41.83 143.72,40 141.76,38.05 v1(141.76,37.72)
  BOTTOM w0.089: 110.17,51.92 109.15,51.92 108.87,52.2 108.87,52.51 U22.BJ4
  BOTTOM w0.127: U25.N3 141.05,56.58 141.05,55.85 141.2,55.71 141.67,55.71 141.78,55.6 v1(141.78,55.3) ; v1(141.76,37.72) 141.76,38.02 141.66,38.12 141.48,38.12 141.28,37.93 141.1,37.93 140.98,38.05 140.98,38.25 141.18,38.45 U30.N3
  BOTTOM w0.203: 110.17,51.92 114.78,51.92 v1(115.6,51.1) 115.98,50.72 116.3,50.72 120.39,46.63 121.3,46.63 121.47,46.45 121.47,45.48 121.65,45.31 121.91,45.31 122.08,45.48 122.08,46.45 122.26,46.63 122.51,46.63 122.69,46.45 122.69,45.38 122.87,45.2 123.12,45.2 123.3,45.38 123.3,46.45 123.48,46.63 123.82,46.63 124.21,46.24 124.21,45.99 123.92,45.71 123.92,45.45 124.1,45.27 124.35,45.27 124.64,45.56 124.89,45.56 125.25,45.2 127.69,45.2 130.56,48.06 135.42,48.06 136.23,48.87 136.98,48.87 137.58,48.26 137.88,48.26 138.49,48.87 138.81,48.87 138.95,48.74 138.95,48.46 138.29,47.81 138.29,47.55 138.47,47.37 139.71,47.37 142.05,49.71 142.59,49.71 142.93,49.37 142.93,48.79 143.16,48.56 143.93,48.56 144.53,49.17 145.52,49.17 146.19,49.84 146.46,49.84 146.65,49.65 146.65,49.38 145.68,48.41 v1(144.6,48.41)
M_B_A5: length 96.8
  TOP w0.127: U9.P8 142.39,57.1 142.39,56.59 142.62,56.36 143.03,56.36 143.29,56.11 144.05,56.11 144.13,56.18 144.89,56.18 145.18,55.89 145.18,54.9 v1(145.13,54.85) ; U13.P8 142.35,39.36 142.35,38.85 142.62,38.58 143.03,38.58 143.29,38.33 144.38,38.33 144.89,37.82 144.89,36.96 v1(144.88,36.96)
  TOP w0.203: v1(147.52,46.66) 147.67,46.81 R220.2
  IN3 w0.178: v1(145.13,54.85) 145.02,54.73 145.02,54.56 147.43,52.14 147.43,51.03 147.2,50.8 147.2,50.44 147.39,50.25 147.65,50.25 147.81,50.1 147.81,49.88 147.65,49.72 147.29,49.72 147.15,49.58 147.15,49.3 147.33,49.12 147.66,49.12 147.81,48.97 147.81,46.95 v1(147.52,46.66) 147.33,46.47 147.33,40.41 144.9,37.98 144.9,36.97 v1(144.88,36.96)
  BOTTOM w0.089: 110.08,50.12 109.61,50.6 108.34,50.6 107.72,51.21 107.72,51.81 107.49,52.04 107.37,52.16 U22.BL6
  BOTTOM w0.127: U25.P8 141.98,52.46 142.09,52.35 142.27,52.35 142.44,52.51 142.44,53.02 142.35,53.11 142.35,53.56 142.91,54.13 144.53,54.13 145.13,54.72 v1(145.13,54.85) ; U30.P8 141.98,34.71 142.07,34.62 142.3,34.62 142.44,34.76 142.44,35.24 142.35,35.33 142.35,35.78 142.71,36.14 143.16,36.14 143.36,36.35 144.08,36.35 144.69,36.96 v1(144.88,36.96)
  BOTTOM w0.203: 110.08,50.12 110.2,50 112.67,50 112.78,50.11 112.78,50.41 112.89,50.52 113.49,50.52 114.05,49.96 114.05,49.49 v1(114.71,48.83) 115.56,47.98 115.78,47.98 116.27,48.48 116.53,48.48 116.71,48.3 116.71,48.04 116.19,47.53 116.19,47.32 116.66,46.84 116.87,46.84 117,46.98 117,47.4 117.18,47.58 117.44,47.58 117.61,47.4 117.61,46.98 117.76,46.84 118.18,46.84 121.19,43.83 128.31,43.83 130.49,46 130.84,46 131.02,45.82 131.02,45.41 131.2,45.23 131.45,45.23 131.63,45.41 131.63,45.82 131.81,46 132.23,46 132.59,45.64 132.88,45.64 133.23,46 135.18,46 135.58,46.4 137.5,46.4 137.91,46 140.28,46 141.48,47.19 143.36,47.19 143.54,47.01 144.61,47.01 144.82,46.8 144.82,46.46 145.36,45.92 145.62,45.92 145.8,46.1 145.8,46.81 146.01,47.01 146.48,47.01 146.67,46.82 146.67,46.08 146.9,45.85 147.15,45.85 147.3,46 147.3,46.44 v1(147.52,46.66)
M_B_A6: length 97.9
  TOP w0.127: U13.P2 141.98,35.22 142.37,35.61 142.37,35.81 142.66,36.09 143.13,36.09 143.4,36.36 144.09,36.36 144.38,36.65 144.38,37.19 144.45,37.26 v1(144.45,37.58) ; v1(144.73,55.75) 144.69,55.7 144.69,54.58 144.23,54.13 142.91,54.13 142.37,53.59 142.37,53.39 141.98,53 U9.P2
  TOP w0.203: R211.2 148,47.67 v1(147.28,47.67)
  IN3 w0.178: v1(144.45,37.58) 144.45,38.02 147.02,40.59 147.02,47.42 v1(147.28,47.67) 147.43,47.83 147.43,48.47 146.81,49.09 146.81,52.23 144.69,54.35 144.69,55.06 144.24,55.51 144.24,56.35 144.41,56.51 144.61,56.51 144.74,56.39 144.74,55.75 v1(144.73,55.75)
  BOTTOM w0.089: 109.02,51.46 108.26,52.22 108.26,52.7 108.08,52.89 U22.BJ5
  BOTTOM w0.127: v1(144.73,55.75) 144.58,55.6 144.28,55.6 144.02,55.85 143.54,55.85 143.11,56.28 142.6,56.28 142.32,56.56 142.32,57.1 142.42,57.2 142.42,57.76 142.27,57.91 142.07,57.91 141.98,57.82 U25.P2 ; U30.P2 142.18,39.93 142.32,39.93 142.44,39.81 142.44,39.43 142.32,39.32 142.32,38.83 142.65,38.5 143.11,38.5 143.54,38.07 144.13,38.07 144.45,37.75 v1(144.45,37.58)
  BOTTOM w0.203: 109.02,51.46 114.56,51.46 v1(116.15,49.87) 116.44,49.87 121.57,44.74 127.88,44.74 130.75,47.6 135.62,47.6 136.38,48.36 136.84,48.36 138.28,46.91 139.9,46.91 141.68,48.69 142.32,48.69 142.91,48.11 143.92,48.11 144.1,47.93 145.84,47.93 146.86,48.94 147.73,48.94 148.32,48.36 148.93,48.36 149.18,48.61 149.18,49.76 149.38,49.96 149.71,49.96 149.89,49.78 149.89,48.18 149.38,47.67 148.11,47.67 147.73,48.06 147.53,48.06 147.28,47.8 v1(147.28,47.67)
M_B_A7: length 98
  TOP w0.127: U13.R8 143.19,39.32 145.19,39.32 146.69,37.82 146.69,36.69 v1(146.64,36.64) ; v1(146.87,54.85) 146.87,55.6 145.37,57.1 143.19,57.1 U9.R8
  TOP w0.203: R230.2 149.66,45.77 v1(149.64,45.79)
  IN3 w0.178: v1(146.87,54.85) 146.87,54.68 148.52,53.03 148.88,53.03 150.17,51.74 150.17,48.28 149.4,47.51 149.4,46.04 v1(149.64,45.79) 149.77,45.67 149.77,44.96 149.49,44.68 149.49,44.02 149.77,43.74 149.77,40.61 149.37,40.22 148.96,40.22 146.71,37.96 146.71,37.29 146.87,37.13 146.87,36.87 v1(146.64,36.64)
  BOTTOM w0.089: U22.BJ9 106.35,53.05 106.54,52.86 106.64,52.71 106.64,52.59 106.54,52.44 106.52,52.43 106.52,52.19 106.62,52.09 106.68,51.97 106.68,51.49 108.34,49.83 109.08,49.83 109.42,49.49
  BOTTOM w0.127: v1(146.87,54.85) 146.48,54.45 146.06,54.45 144.71,53.11 144.49,53.11 144.38,53.22 144.38,53.43 144.27,53.54 144.06,53.54 143.95,53.43 143.95,53.25 143.83,53.14 143.52,53.14 143.01,52.63 142.86,52.63 U25.R8 ; v1(146.64,36.64) 146.49,36.8 146.31,36.8 146.16,36.65 146.16,35.99 145.5,35.33 144.91,35.33 144.78,35.46 144.78,35.76 144.66,35.89 144.49,35.89 144.35,35.75 144.35,35.47 144.24,35.36 143.52,35.36 143.09,34.93 U30.R8
  BOTTOM w0.203: 109.42,49.49 109.82,49.09 113.09,49.09 v1(115.88,46.3) 117.09,45.08 118.64,45.08 120.81,42.91 128.69,42.91 130.1,44.31 133.55,44.31 133.73,44.5 140.07,44.5 141.85,46.28 142.91,46.28 143.08,46.1 143.89,46.1 145.11,44.88 146.82,44.88 147.3,44.4 149.41,44.4 149.94,44.93 149.94,45.49 v1(149.64,45.79)
M_B_A8: length 103.4
  TOP w0.127: v1(147.76,54.95) 145.98,53.17 142.66,53.17 142.56,53.07 142.56,52.93 U9.R2 ; U13.R2 142.56,35.15 142.56,35.29 142.66,35.39 146.16,35.39 147.54,36.76 v1(147.54,37.06)
  TOP w0.203: R214.2 150.98,46.96 v1(150.48,46.45)
  IN3 w0.178: v1(147.54,37.06) 147.6,37.12 147.6,37.82 148.75,38.96 149.82,38.96 150.48,39.62 v1(150.48,46.45) 150.27,46.66 150.27,47.32 151.01,48.06 151.01,49.22 151.45,49.67 151.45,50.18 151.11,50.52 151.11,50.99 151.45,51.33 151.45,51.78 149.43,53.8 148.91,53.8 v1(147.76,54.95)
  BOTTOM w0.089: 108.95,50.98 108.29,50.98 107.9,51.36 107.9,51.88 107.67,52.11 107.67,52.63 U22.BJ6
  BOTTOM w0.127: U25.R2 143.09,57.51 143.53,57.07 145.62,57.07 146.74,55.95 147.4,55.95 147.76,55.6 v1(147.76,54.95) ; v1(147.54,37.06) 147.58,37.1 147.58,37.77 147.3,38.05 146.34,38.05 145.09,39.29 143.53,39.29 143.09,39.73 U30.R2
  BOTTOM w0.203: v1(150.48,46.45) 150.48,46.56 149.89,47.14 148.53,47.14 148.31,46.91 147.95,46.91 147.72,47.14 147.1,47.14 146.77,47.47 143.77,47.47 143.59,47.65 141.29,47.65 140.09,46.45 138.09,46.45 137.69,46.86 137.16,46.86 136.98,47.04 136.98,47.56 136.78,47.77 136.53,47.77 136.38,47.62 136.38,47.04 136.2,46.86 135.39,46.86 134.99,46.45 133.51,46.45 133.26,46.71 132.9,46.71 132.65,46.45 131.2,46.45 130.97,46.68 130.47,46.68 128.07,44.28 121.38,44.28 116.62,49.05 116.2,49.05 115.81,48.66 115.56,48.66 115.38,48.84 115.38,49.09 115.66,49.37 115.66,49.62 115.48,49.8 115.23,49.8 114.95,49.52 114.7,49.52 114.52,49.7 114.52,49.96 114.87,50.3 114.87,50.51 114.65,50.72 v1(114.03,50.72) 113.77,50.98 111.08,50.98 110.93,50.83 110.93,50.61 110.78,50.46 110.48,50.46 110.32,50.61 110.32,50.82 110.17,50.98 108.95,50.98
M_B_A9: length 98
  TOP w0.127: U13.R7 143.09,38.93 143.44,38.59 143.85,38.59 143.9,38.63 144.91,38.63 145.78,37.77 145.78,36.78 v1(145.72,36.73) ; U9.R7 143.09,56.71 143.44,56.37 143.85,56.37 144.08,56.59 145.04,56.59 146.02,55.61 v1(146.02,54.87)
  TOP w0.203: R241.2 149.82,45.29 149.05,45.29 148.55,45.79 v1(148.55,45.87)
  IN3 w0.178: v1(146.02,54.87) 146.02,54.54 148.34,52.22 148.34,51.71 149.12,50.94 149.12,48.52 148.55,47.95 v1(148.55,45.87) 148.7,45.72 148.7,43.61 148.19,43.1 148.19,40.33 145.79,37.93 145.79,37.4 145.93,37.26 145.93,36.93 v1(145.72,36.73)
  BOTTOM w0.089: U22.BJ8 107.07,52.69 107.07,52.27 107.11,52.17 107.31,51.97 107.53,51.75 107.53,51.05 108.34,50.24 109.32,50.24 109.76,49.8
  BOTTOM w0.127: U30.R7 142.78,35.56 142.91,35.43 143.06,35.43 143.21,35.58 143.21,35.85 143.44,36.07 144.18,36.07 144.53,36.42 144.89,36.42 145.03,36.28 145.03,36.05 145.14,35.94 145.35,35.94 145.47,36.07 145.47,36.48 v1(145.72,36.73) ; v1(146.02,54.87) 145.79,54.87 144.77,53.85 143.37,53.85 143.21,53.69 143.21,53.24 143.06,53.08 142.88,53.08 142.78,53.19 U25.R7
  BOTTOM w0.203: v1(148.55,45.87) 148.55,46.51 148.72,46.68 149,46.68 149.16,46.53 149.16,45.59 149.43,45.31 149.43,45.07 149.22,44.85 148.98,44.85 148.6,45.24 148.27,45.24 147.89,44.85 147.56,44.85 147.07,45.34 145.3,45.34 144.08,46.56 143.27,46.56 143.1,46.73 141.66,46.73 140.47,45.54 137.72,45.54 137.31,45.95 137.07,45.95 136.87,45.75 136.87,45.29 136.66,45.08 136.4,45.08 136.26,45.23 136.26,45.71 136.1,45.87 135.82,45.87 135.64,45.69 135.64,45.08 135.51,44.95 133.43,44.95 133.25,44.77 131.01,44.77 130.65,45.13 130.27,45.13 128.5,43.37 121,43.37 118.83,45.54 118.42,45.54 118.28,45.69 118.28,46.1 118.07,46.3 117.85,46.3 117.67,46.12 117.67,45.67 117.53,45.54 117.32,45.54 v1(115.36,47.5) 113.31,49.54 110.01,49.54 109.76,49.8
M_B_A10: length 86.1
  TOP w0.127: v1(139.96,37.58) 139.96,36.93 139.81,36.78 139.81,36.34 140.38,35.77 U13.M3 ; v1(140.05,55.38) 140.05,54.19 140.38,53.86 U9.M3
  TOP w0.203: v1(142.31,45.79) 142.25,45.73 142.25,44.91 R238.2
  IN1 w0.089: v1(105.9,54.32) 106.29,53.94 106.29,53.3 107.78,51.81 107.78,51.41 108.08,51.1
  IN1 w0.127: 108.08,51.1 108.17,51.1 110.37,48.91 114.99,48.91 115.11,48.78 115.11,48.44 115.26,48.28 115.47,48.28 115.62,48.44 115.62,48.78 115.75,48.91 116.4,48.91 116.52,48.79 116.52,48.6 115.82,47.91 115.82,47.7 115.97,47.55 116.18,47.55 116.86,48.23 117.07,48.23 117.22,48.08 117.22,47.87 116.54,47.19 116.54,46.98 116.69,46.83 116.9,46.83 117.58,47.51 117.79,47.51 117.94,47.36 117.94,47.15 117.26,46.47 117.26,46.26 117.41,46.11 117.62,46.11 118.27,46.76 118.55,46.76 121.21,44.09 129.32,44.09 129.79,44.56 129.97,44.56 130.41,44.12 130.62,44.12 130.77,44.27 130.77,44.48 130.33,44.92 130.33,45.1 130.51,45.28 130.69,45.28 131.1,44.87 131.31,44.87 131.46,45.02 131.46,45.23 131.05,45.64 131.05,45.82 131.47,46.24 132.51,46.24 132.72,46.02 132.72,45.34 133.01,45.04 133.7,45.04 133.92,45.26 133.92,46.02 134.13,46.24 135.65,46.24 136.42,47 140.71,47 141.91,45.79 v1(142.31,45.79)
  IN3 w0.178: v1(139.96,37.58) 139.96,37.92 140.21,38.17 140.21,38.35 141.79,39.93 141.79,42.57 141.95,42.73 142.32,42.73 142.48,42.89 142.48,43.11 142.32,43.26 141.92,43.26 141.76,43.42 141.76,43.66 141.92,43.81 142.3,43.81 142.45,43.97 142.45,44.17 142.31,44.31 v1(142.31,45.79) 142.37,45.86 142.37,49.9 141.79,50.49 141.79,52.55 140.05,54.29 v1(140.05,55.38)
  BOTTOM w0.089: U22.BF11 v1(105.9,54.32)
  BOTTOM w0.127: v1(139.96,37.58) 139.71,37.58 139.58,37.72 139.58,37.95 139.73,38.1 140.01,38.1 140.38,38.47 U30.M3 ; U25.M3 140.44,56.65 140.44,56.23 140.21,56.01 139.99,56.01 139.76,55.78 139.76,55.52 139.9,55.38 v1(140.05,55.38)
M_B_A11: length 105.2
  TOP w0.127: U9.T2 146.16,52.71 148.2,54.75 v1(148.2,55.42) ; U13.T2 146.16,34.93 148.05,36.81 v1(148.05,37.58)
  TOP w0.203: R244.2 151.17,44.76 v1(150.95,44.98)
  IN3 w0.178: v1(148.2,55.42) 148.2,55.13 149.14,54.2 149.61,54.2 151.96,51.85 151.96,48.23 150.95,47.22 v1(150.95,44.98) 150.88,44.91 150.88,44.67 151.04,44.51 151.49,44.51 151.64,44.36 151.64,43.7 151.49,43.55 151.04,43.55 150.88,43.39 150.88,43.17 151.04,43.01 151.49,43.01 151.64,42.86 151.64,42.64 151.49,42.48 151.04,42.48 150.88,42.33 150.88,42.1 151.04,41.95 151.46,41.95 151.62,41.79 151.62,41.57 151.46,41.41 151.04,41.41 150.88,41.26 150.88,39.42 149.94,38.48 148.8,38.48 148.05,37.73 v1(148.05,37.58)
  BOTTOM w0.089: 106.43,49.82 105.34,50.9 105.34,51.89 105.44,52.2 U22.BK11
  BOTTOM w0.127: v1(148.2,55.42) 148.2,55.66 147.03,56.83 146.87,56.83 146.76,56.73 146.58,56.73 146.44,56.86 146.44,57.05 146.55,57.16 146.55,57.31 146.36,57.51 U25.T2 ; v1(148.05,37.58) 148.29,37.83 148.29,38.1 148.01,38.38 146.51,38.38 145.16,39.73 U30.T2
  BOTTOM w0.203: v1(150.95,44.98) 150.65,44.98 149.61,43.94 147.6,43.94 146.47,42.81 143.56,42.81 143.26,43.1 142.01,43.1 141.57,42.67 134.58,42.67 134.39,42.49 v1(134.07,42.49) 131.03,42.49 129.29,40.75 127.08,40.75 126.1,39.77 118.89,39.77 117.13,41.53 116.05,41.53 111.36,46.22 110.93,46.22 109.88,47.26 108.99,47.26 106.43,49.82
M_B_A12: length 94.2
  TOP w0.127: U9.M7 140.38,56.32 140.5,56.21 v1(140.5,54.82) ; U13.M7 140.38,36.68 v1(140.25,36.55)
  TOP w0.203: R235.2 143.26,44.74 143.26,43.05 v1(142.83,42.62)
  IN3 w0.178: v1(140.25,36.55) 140.25,34.59 140.09,34.44 139.86,34.44 139.73,34.57 139.73,35 139.58,35.16 139.08,35.16 138.92,35.31 138.92,35.53 139.08,35.69 139.58,35.69 139.73,35.85 139.73,36.68 140.4,37.35 140.4,37.9 140.54,38.05 140.54,38.25 142.12,39.83 142.12,41.91 v1(142.83,42.62) 142.83,44.29 142.75,44.38 142.75,46.32 142.68,46.39 142.68,52.12 140.5,54.3 v1(140.5,54.82)
  BOTTOM w0.089: U22.BJ12 104.86,52.83 104.86,52.73 104.96,52.63 105.06,52.63 105.27,52.42 105.27,52.31 105.14,51.95 105.14,50.48 106.27,49.34 106.27,49.33
  BOTTOM w0.127: v1(140.5,54.82) 140.5,54.71 140.34,54.56 140.09,54.56 139.96,54.43 139.96,54.28 140.09,54.15 140.24,54.15 140.38,54.01 U25.M7 ; v1(140.25,36.55) 139.99,36.8 139.86,36.8 139.74,36.69 139.74,36.38 140,36.12 140.52,36.12 140.61,36.03 140.61,35.81 140.53,35.73 U30.M7
  BOTTOM w0.203: 106.27,49.33 108.8,46.8 109.7,46.8 110.74,45.76 111.17,45.76 115.86,41.07 116.94,41.07 118.72,39.29 119.63,39.29 119.81,39.11 119.81,38.2 119.96,38.05 120.27,38.05 120.42,38.2 120.42,39.17 120.57,39.32 120.88,39.32 121.03,39.17 121.03,38.23 121.18,38.08 121.49,38.08 121.64,38.23 121.64,39.17 121.79,39.32 122.09,39.32 122.25,39.17 122.25,38.24 122.4,38.09 122.7,38.09 122.86,38.24 122.86,39.11 123.04,39.29 v1(123.27,39.29) 123.53,39.29 123.72,39.1 123.72,38.35 123.9,38.17 124.15,38.17 124.33,38.35 124.33,39.17 124.48,39.32 124.79,39.32 124.94,39.17 124.94,38.41 125.09,38.26 125.4,38.26 125.55,38.41 125.55,39.13 125.71,39.29 126.27,39.29 127.27,40.3 129.48,40.3 131.22,42.04 133.28,42.04 133.66,41.65 134.47,41.65 135.06,42.24 141.79,42.24 142.17,42.62 v1(142.83,42.62)
M_B_A13: length 95.2
  TOP w0.127: U9.T8 145.52,57.51 145.93,57.1 146.08,57.1 146.19,57.21 146.37,57.21 146.5,57.08 146.5,56.9 146.4,56.81 146.4,56.62 147.31,55.71 v1(147.31,55.4) ; v1(147.16,37.58) 147.16,38.01 146.36,38.81 146.36,38.98 146.53,39.15 146.53,39.33 146.4,39.46 146.22,39.46 146.05,39.29 145.88,39.29 145.44,39.73 U13.T8
  TOP w0.203: R213.2 149.99,46.66 v1(149.84,46.51)
  IN1 w0.127: v1(110.65,52.96) 110.65,52.78 111.17,52.26 116.22,52.26 120.91,56.94 124.75,56.94 129.32,52.37 129.32,52.12 131.77,49.67 137.71,49.67 138.32,50.28 147.37,50.28 148.39,49.26 148.84,49.26 149.84,48.26 v1(149.84,46.51)
  IN3 w0.178: v1(147.16,37.58) 147.16,37.88 148.6,39.32 149.49,39.32 150.15,39.98 150.15,46.05 149.84,46.35 v1(149.84,46.51) 149.84,47.37 150.57,48.09 150.57,51.9 149.08,53.39 148.69,53.39 147.32,54.76 147.32,55.4 v1(147.31,55.4)
  BOTTOM w0.079: 110.57,53.64 109.94,54.28 109.3,54.28 109.28,54.25 108.68,54.25 U22.BE5
  BOTTOM w0.089: 110.57,53.64 110.65,53.57 v1(110.65,52.96)
  BOTTOM w0.127: U30.T8 145.73,34.93 147.12,36.32 147.12,37.55 v1(147.16,37.58) ; U25.T8 144.82,52.71 146.23,54.13 146.79,54.13 147.31,54.65 v1(147.31,55.4)
M_B_A14: length 93.3
  TOP w0.127: U9.L2 139.94,53.07 139.94,53.67 139.02,54.58 v1(139.02,55.12) ; v1(139.05,37.58) 139.05,37.23 139.08,37.21 139.08,36.71 139.94,35.86 139.94,35.6 139.58,35.24 U13.L2
  TOP w0.203: R237.2 141.28,45.02 v1(141.42,45.16)
  IN3 w0.178: v1(139.02,55.12) 139.02,54.68 139.33,54.38 139.33,54.05 140.52,52.86 140.52,51.36 141.06,50.82 141.06,48.82 140.87,48.63 140.87,46.39 141.42,45.84 v1(141.42,45.16) 141.23,45.16 141,44.93 141,44.68 141.23,44.45 141.23,44.09 140.6,43.46 140.6,43.23 140.72,43.1 141,43.1 141.15,42.94 141.15,42.72 141,42.57 140.78,42.57 140.62,42.41 140.62,42.19 140.78,42.03 141,42.03 141.15,41.88 141.15,41.66 141,41.5 140.78,41.5 140.54,41.27 140.54,40.34 140.77,40.11 140.77,39.9 140.6,39.72 140.41,39.72 140.2,39.93 139.99,39.93 139.85,39.79 139.85,39.1 139.48,38.73 139.48,38.26 139.05,37.84 v1(139.05,37.58)
  BOTTOM w0.089: U22.BK9 106.35,52.12 106.48,51.99 106.5,51.94 106.5,51.91 106.5,51.91 106.5,51.34 108.39,49.45 108.81,49.45 109.09,49.17
  BOTTOM w0.127: U30.L2 139.75,39.9 139.88,39.9 140.04,39.75 140.04,38.9 139.05,37.92 v1(139.05,37.58) ; U25.L2 139.96,57.13 139.96,56.54 139.5,56.08 139.5,55.6 v1(139.02,55.12)
  BOTTOM w0.203: v1(141.42,45.16) 141.38,45.16 140.9,44.68 140.9,44.27 140.67,44.04 133.92,44.04 133.73,43.86 130.29,43.86 128.88,42.45 120.62,42.45 118.61,44.47 118.42,44.47 118.29,44.35 118.29,43.91 117.6,43.22 117.24,43.22 117.1,43.36 117.1,43.58 117.68,44.17 117.68,44.5 117.56,44.63 117.26,44.63 116.18,43.55 115.97,43.55 115.75,43.76 115.75,43.98 116.51,44.73 116.51,44.98 116.33,45.16 116.08,45.16 115.32,44.41 115.11,44.41 114.89,44.62 114.89,44.84 115.64,45.59 115.64,45.85 115.47,46.03 115.21,46.03 114.46,45.27 114.24,45.27 114.03,45.49 114.03,45.7 114.78,46.46 114.78,46.71 114.6,46.89 114.35,46.89 v1(114.06,46.6) 113.6,46.13 113.38,46.13 113.17,46.35 113.17,46.57 113.92,47.32 113.92,47.57 113.74,47.75 113.49,47.75 112.76,47.03 112.55,47.03 112.33,47.24 112.33,47.46 113.06,48.18 113.06,48.43 112.86,48.63 112.59,48.63 111.63,47.67 111.42,47.67 111.16,47.92 111.16,48.14 111.36,48.33 111.36,48.49 111.22,48.63 109.63,48.63 109.09,49.17
M_B_A15: length 92.9
  TOP w0.127: v1(141.19,37.44) 140.77,37.86 140.77,39.75 140.67,39.85 140.5,39.85 U13.M8 ; v1(141.39,54.79) 141.36,54.81 141.36,55.47 140.77,56.06 140.77,57 140.38,57.39 U9.M8
  TOP w0.203: v1(143.9,45.41) 144.69,45.41 144.97,45.13 R231.2
  IN3 w0.178: v1(141.39,54.79) 141.39,54.35 143.29,52.45 143.29,46.91 143.9,46.3 v1(143.9,45.41) 143.69,45.21 143.69,44.7 143.9,44.5 143.9,42.52 143.39,42.01 143.39,41.73 143.22,41.57 142.89,41.57 142.73,41.4 142.73,40.82 142.87,40.68 143.24,40.68 143.39,40.52 143.39,40.35 143.21,40.17 142.87,40.17 142.73,40.03 142.73,39.5 141.19,37.96 v1(141.19,37.44)
  BOTTOM w0.089: U22.BJ11 105.4,53.27 105.32,53.19 105.32,53.03 105.39,52.96 105.53,52.96 105.64,52.84 105.73,52.71 105.73,52.59 105.63,52.44 105.62,52.43 105.62,52.01 105.54,51.76 105.54,51.35 106.84,50.05
  BOTTOM w0.127: v1(141.39,54.79) 141.13,54.79 140.75,54.41 140.75,53.34 140.57,53.16 140.24,53.16 140.11,53.03 140.11,52.83 140.23,52.71 U25.M8 ; U30.M8 140.84,35.39 140.84,35.87 141.33,36.37 141.33,37.3 v1(141.19,37.44)
  BOTTOM w0.203: 106.84,50.05 109.18,47.71 110.07,47.71 111.12,46.67 111.55,46.67 116.24,41.98 117.18,41.98 117.46,42.26 117.72,42.26 117.96,42.02 117.96,41.34 119.07,40.23 120.12,40.23 120.65,40.77 124.88,40.77 125.41,40.23 125.91,40.23 127.16,41.48 v1(127.82,41.48) 128.09,41.21 129.1,41.21 130.84,42.94 134.11,42.94 134.3,43.13 141.36,43.13 141.84,43.6 141.84,44.25 142.06,44.47 142.29,44.47 142.44,44.32 142.44,43.88 142.62,43.7 142.88,43.7 143.05,43.88 143.05,44.77 143.23,44.94 143.49,44.94 143.66,44.77 143.66,43.54 143.94,43.27 146.22,43.27 146.41,43.46 146.41,43.74 146.24,43.91 144.46,43.91 144.28,44.09 144.28,45.03 v1(143.9,45.41)
M_B_A16: length 89.1
  TOP w0.127: U9.L8 139.96,57.13 139.96,55.88 139.6,55.52 v1(139.6,54.86) ; v1(139.5,37.08) 139.5,37.72 139.96,38.18 139.96,39.35 U13.L8
  TOP w0.203: v1(141.86,48.13) 142.47,48.13 R209.2
  IN1 w0.089: 110.75,51.5 110.1,51.5 108.59,53.01 108.21,53.01 107.85,53.37 v1(107.85,53.95)
  IN1 w0.127: 110.75,51.5 115.61,51.5 116.36,50.75 117.15,50.75 120.68,47.22 124.13,47.22 125.43,45.92 127.52,45.92 130.49,48.89 138.01,48.89 138.64,49.52 146.45,49.52 146.68,49.29 146.68,49.03 146.48,48.83 146.03,48.83 145.88,48.68 145.88,47.95 145.73,47.8 145.52,47.8 145.37,47.95 145.37,48.68 145.22,48.83 142.56,48.83 v1(141.86,48.13)
  IN3 w0.178: v1(139.6,54.86) 139.71,54.75 139.71,54.15 140.82,53.03 140.82,52.7 141,52.53 141.33,52.53 141.48,52.37 141.48,52.09 141.34,51.94 140.98,51.94 140.82,51.79 140.82,51.57 140.98,51.41 141.33,51.41 141.48,51.25 141.48,48.66 141.21,48.39 141.21,46.76 141.33,46.63 141.56,46.63 141.69,46.76 141.69,47.96 v1(141.86,48.13) 142.05,47.94 142.05,46.28 141.86,46.09 141.86,44.24 141.48,43.86 141.48,40.05 139.88,38.45 139.88,38.28 139.5,37.89 139.5,37.08 v1(139.5,37.08)
  BOTTOM w0.089: U22.BH5 107.88,53.91 v1(107.85,53.95)
  BOTTOM w0.127: v1(139.6,54.86) 139.6,54.21 140.01,53.8 140.01,53.41 139.76,53.16 139.45,53.16 139.33,53.03 139.33,52.83 139.45,52.71 U25.L8 ; v1(139.5,37.08) 139.5,36.29 139.96,35.83 139.96,35.51 139.83,35.38 139.45,35.38 139.33,35.25 139.33,35.05 139.45,34.93 U30.L8
M_B_ACT#: length 88.3
  TOP w0.127: v1(140.05,48.47) 140.02,48.5 138.61,48.5 R208.2 ; v1(138.16,37.46) 138.16,36.79 138.48,36.47 138.84,36.47 U13.L3 ; v1(138.13,55.35) 138.13,54.96 U9.L3
  IN1 w0.089: v1(107.6,54.54) 107.32,54.27 107.32,53.59 108.13,52.78 108.41,52.78 109.58,51.62
  IN1 w0.127: v1(140.05,48.47) 140.05,48.75 139.82,48.98 138.86,48.98 138.23,48.36 130.71,48.36 129.36,47.01 129.36,46.83 129.69,46.5 129.69,46.3 129.54,46.14 129.33,46.14 129,46.47 128.82,46.47 128.64,46.29 128.64,46.11 128.97,45.78 128.97,45.58 128.82,45.42 128.61,45.42 128.28,45.75 128.1,45.75 127.74,45.39 124.7,45.39 124.57,45.52 124.57,46.02 124.39,46.2 124.21,46.2 124.06,46.05 124.06,45.52 123.94,45.39 123.68,45.39 123.55,45.52 123.55,46.53 123.41,46.68 123.2,46.68 123.05,46.53 123.05,45.52 122.92,45.39 122.67,45.39 122.54,45.52 122.54,46.53 122.39,46.68 122.18,46.68 122.03,46.53 122.03,45.52 121.9,45.39 121.75,45.39 121.26,45.88 121.26,46.06 121.55,46.35 121.55,46.56 121.42,46.68 121.16,46.68 120.9,46.42 120.72,46.42 116.94,50.2 115.82,50.2 115.68,50.34 115.68,50.67 115.42,50.93 115.27,50.93 115.14,50.8 115.14,50.33 115.02,50.2 114.76,50.2 114.63,50.33 114.63,50.84 114.51,50.96 114.25,50.96 114.13,50.84 114.13,50.33 114,50.2 113.75,50.2 113.62,50.33 113.62,50.84 113.49,50.96 113.24,50.96 113.11,50.84 113.11,50.33 112.98,50.2 112.73,50.2 112.6,50.33 112.6,50.81 112.45,50.96 110.08,50.96 109.58,51.47 109.58,51.62
  IN3 w0.14: v1(138.13,55.35) 138.03,55.25 138.03,54.81 138.67,54.17 138.67,53.16 138.77,53.06 138.92,53.06 139.06,53.2 139.24,53.2 139.37,53.06 139.37,52.88 139.18,52.69 139.18,52.51 139.32,52.38 139.5,52.38 139.68,52.57 139.87,52.57 139.95,52.48 139.95,49.99 140.16,49.78 140.16,49.05 140.04,48.92 139.78,48.92 139.66,49.05 139.66,49.53 139.54,49.65 139.32,49.65 139.17,49.5 139.17,48.59 139.29,48.48 140.05,48.48 v1(140.05,48.47) 140.14,48.38 140.14,45.74 140.34,45.54 140.34,44.27 139.94,43.86 139.94,40.64 139.31,40.01 139.31,39.4 138.79,38.89 138.79,38.37 138.16,37.75 v1(138.16,37.46)
  BOTTOM w0.089: U22.BE7 107.17,54.98 v1(107.6,54.54)
  BOTTOM w0.127: v1(138.13,55.35) 138.13,55.35 138.13,55.45 139.12,56.44 139.12,56.79 139.25,56.92 139.37,56.92 U25.L3 ; v1(138.16,37.46) 138.16,37.57 139.12,38.53 139.12,39.01 139.22,39.11 139.4,39.11 U30.L3
M_B_ALERT#: length 57.1
  TOP w0.127: U13.P9 142,40.53 142.42,40.1 146.29,40.1 146.99,39.4 146.99,38.88 147.75,38.12 148.24,38.12 148.6,37.77 148.6,37.21 v1(148.47,37.08) ; v1(149.23,54.74) 149.1,54.74 148.7,55.14 148.7,55.72 146.53,57.88 142.42,57.88 142,58.31 U9.P9
  IN3 w0.14: v1(148.47,37.08) 148.53,37.14 148.53,37.64 148.99,38.1 150.12,38.1 152.08,40.06 152.08,45.51 151.41,46.18 151.41,47.16 v1(152.69,48.44) 152.22,48.9 152.22,52 149.49,54.74 v1(149.23,54.74)
  BOTTOM w0.127: v1(152.69,48.44) 152.19,48.94 R536.1 ; U30.P9 142.28,34.13 142.64,34.49 145.88,34.49 v1(148.47,37.08) ; v1(149.23,54.74) 148.39,54.74 147.38,53.72 146.69,53.72 145.24,52.27 142.64,52.27 142.28,51.91 U25.P9
M_B_BA#0: length 87
  TOP w0.127: U9.N2 141.58,53.11 141.58,53.64 142.15,54.2 142.22,54.2 142.81,54.79 v1(142.81,55.26) ; U13.N2 141.58,35.33 141.58,35.81 141.93,36.17 142.09,36.17 142.5,36.58 142.5,37.38 v1(142.66,37.54)
  TOP w0.203: R217.2 145.36,46.72 145.3,46.66 v1(145.3,46.67)
  IN1 w0.089: v1(106.85,53.61) 106.98,53.61 108.1,52.49 108.35,52.49 109.15,51.69
  IN1 w0.127: 109.15,51.69 109.15,51.38 110.86,49.67 116.72,49.67 121.53,44.85 129.01,44.85 130.33,46.18 130.33,47.19 130.97,47.83 138.45,47.83 139.02,48.39 139.33,48.39 139.9,47.83 140.96,47.83 141.9,46.89 142.2,46.89 142.44,47.13 142.44,48.17 142.59,48.32 142.8,48.32 142.95,48.17 142.95,47.04 143.1,46.89 143.31,46.89 143.46,47.04 143.46,48.3 143.61,48.45 143.82,48.45 143.96,48.3 143.96,47.04 144.11,46.89 144.32,46.89 144.47,47.04 144.47,47.73 144.62,47.88 144.83,47.88 144.98,47.73 144.98,46.99 v1(145.3,46.67)
  IN3 w0.178: 145.3,46.66 v1(145.3,46.67) ; 145.3,46.66 145.24,46.6 145.24,42.39 144.3,41.45 144.3,39.7 142.53,37.92 142.53,37.68 v1(142.66,37.54) ; 145.3,46.66 145.45,46.81 145.45,49.68 145.27,49.86 145.12,49.86 144.96,50.02 144.96,50.24 145.12,50.39 145.35,50.39 145.47,50.52 145.47,50.67 144.89,51.26 144.89,52.25 142.81,54.32 v1(142.81,55.26)
  BOTTOM w0.089: U22.BH6 v1(106.85,53.61)
  BOTTOM w0.127: v1(142.66,37.54) 142.66,37.68 142.48,37.87 142.27,37.87 141.61,38.53 141.61,39.77 141.51,39.88 141.33,39.88 U30.N2 ; v1(142.81,55.26) 142.49,55.26 141.56,56.19 141.56,57.4 141.45,57.51 U25.N2
M_B_BA#1: length 93.5
  TOP w0.127: v1(142.97,36.89) 143.08,37 143.08,37.75 142.8,38.03 142.42,38.03 141.9,38.54 141.83,38.54 141.56,38.81 141.56,39.35 U13.N8 ; v1(143.35,54.87) 143.35,55.3 142.85,55.81 142.34,55.81 141.56,56.59 141.56,56.97 141.18,57.35 U9.N8
  TOP w0.203: R253.2 146.15,43.94 v1(145.69,44.4)
  IN1 w0.089: 107.54,49.58 105.86,51.26 105.7,51.26 105.51,51.45 105.51,52.87 105.08,53.3 104.78,53.3 104.55,53.53 104.55,54 v1(104.95,54.4)
  IN1 w0.127: 107.54,49.58 109.74,47.38 113.98,47.38 118.79,42.57 131.27,42.57 132.22,43.52 135.86,43.52 136.87,44.54 136.87,45.23 137.12,45.48 139.77,45.48 140.06,45.18 140.06,43.3 141.41,41.96 144.61,41.96 145.69,43.04 v1(145.69,44.4)
  IN3 w0.178: v1(142.97,36.89) 142.97,35.8 143.12,35.66 143.32,35.66 143.47,35.8 143.47,37.02 143.11,37.38 143.11,38.04 145.19,40.13 145.19,41.83 145.69,42.33 v1(145.69,44.4) 145.69,46.32 145.78,46.4 145.78,50.82 145.24,51.36 145.24,52.35 143.35,54.24 v1(143.35,54.87)
  BOTTOM w0.089: v1(104.95,54.4) 104.95,54.41 U22.BF13
  BOTTOM w0.127: v1(143.35,54.87) 143.27,54.79 142.76,54.79 141.61,53.64 141.61,52.6 141.51,52.5 141.39,52.5 U25.N8 ; v1(142.97,36.89) 142.8,36.89 142.21,36.29 142.01,36.29 141.54,35.81 141.54,35.33 141.64,35.23 141.64,34.62 141.53,34.51 141.33,34.51 141.18,34.66 U30.N8
M_B_BG#0: length 94.2
  TOP w0.127: U9.M2 140.48,52.61 140.63,52.61 140.72,52.7 140.72,54.34 140.94,54.56 v1(140.94,55.28) ; U13.M2 140,34.93 139.91,35.03 139.91,35.23 140.07,35.39 140.65,35.39 140.75,35.48 140.75,35.96 140.86,36.07 141.16,36.07 141.36,36.27 141.36,36.4 141.25,36.51 v1(140.88,36.51)
  TOP w0.203: R224.2 144.2,46.4 v1(143.23,45.43)
  IN3 w0.178: v1(140.94,55.28) 140.94,55.28 140.94,54.36 142.98,52.32 142.98,46.68 143.23,46.43 v1(143.23,45.43) 143.23,44.5 143.42,44.32 143.42,42.53 142.42,41.54 142.42,39.65 140.9,38.12 140.9,37.9 140.75,37.74 140.75,37.23 140.99,36.99 141.17,36.99 141.31,36.85 141.31,36.65 141.16,36.51 v1(140.88,36.51)
  BOTTOM w0.089: 108.75,48.79 108.64,48.79 106.32,51.11 106.32,51.89 106.17,52.05 106.17,52.42 106.1,52.53 106.1,52.88 106.02,52.96 U22.BJ10
  BOTTOM w0.127: U30.M2 140.38,39.56 140.72,39.22 140.72,38.38 140.62,38.28 140.62,37.21 140.88,36.95 v1(140.88,36.51) ; U25.M2 140.45,57.58 140.67,57.58 140.77,57.48 140.77,56.11 140.54,55.88 140.54,55.42 140.68,55.28 v1(140.94,55.28)
  BOTTOM w0.203: v1(143.23,45.43) 143.07,45.59 142.88,45.59 142.68,45.39 142.68,45.11 142.5,44.93 141.87,44.93 141.36,44.41 141.36,43.89 141.05,43.58 134.11,43.58 133.92,43.4 130.48,43.4 129.07,42 126.56,42 126.39,41.82 126.39,41.35 126.11,41.07 125.91,41.07 125.78,41.21 125.78,41.82 125.62,41.97 125.32,41.97 125.17,41.82 125.17,41.37 125.01,41.22 124.71,41.22 124.56,41.37 124.56,41.82 124.41,41.97 124.1,41.97 123.95,41.82 123.95,41.37 123.8,41.22 123.49,41.22 123.34,41.37 123.34,41.82 123.19,41.97 122.88,41.97 122.73,41.82 122.73,41.37 122.58,41.22 122.27,41.22 122.12,41.37 122.12,41.82 121.97,41.97 121.66,41.97 121.51,41.82 121.51,41.37 121.36,41.22 121.05,41.22 120.9,41.37 120.9,41.82 120.75,41.97 120.49,41.97 120.28,41.75 120.28,41.03 120.03,40.79 119.82,40.79 119.63,40.98 119.63,42.78 118.85,43.56 118.59,43.56 118.4,43.37 118.4,43.1 119.08,42.42 119.08,41.37 118.93,41.22 118.73,41.22 118.42,41.53 118.42,42.21 117.87,42.76 117.31,42.76 116.99,42.44 116.43,42.44 112.28,46.59 v1(112.28,46.62) 111.77,47.13 111.31,47.13 110.26,48.17 109.37,48.17 108.75,48.79
M_B_BG#1: length 96.6
  TOP w0.203: R146.1 140.5,62.67 140.27,62.44 140.27,61.35 140.75,60.87 v1(140.75,60.5) ; R272.1 148.44,41.58 v1(148.88,42.01) 148.97,42.1 R265.2
  IN1 w0.089: 110.34,52.51 110.02,52.83 109.33,52.83 108.71,53.45 v1(108.47,53.45)
  IN1 w0.127: 110.34,52.51 110.98,51.88 116.71,51.88 120.99,47.6 124.29,47.6 125.58,46.3 127.36,46.3 130.33,49.27 137.85,49.27 138.48,49.9 147.21,49.9 148.27,48.84 v1(148.62,48.84) 149.22,48.25 149.22,43.83 149.29,43.75 149.29,42.42 v1(148.88,42.01) 148.67,41.81 148.67,39.32 149.5,38.5 149.5,36.38 145.74,32.62 143.55,32.62 142.37,31.44 v1(142.37,31.42) ; v1(149.33,51.39) 149.33,51.39 149.33,53.59 149.97,54.23 149.97,57.33 148.1,59.21 148.1,60.34 147.3,61.14 144.69,61.14 143.67,62.15 142.4,62.15 v1(140.75,60.5)
  BOTTOM w0.089: U22.BG4 108.46,53.95 v1(108.47,53.45)
  BOTTOM w0.203: v1(142.37,31.42) 142.37,30.37 R558.1 ; v1(148.62,48.84) 148,49.47 R535.1 148,49.92 148.24,50.16 148.87,50.16 149.18,50.47 149.18,51.23 149.33,51.38 v1(149.33,51.39)
M_B_BG#1_1: length 5.3
  TOP w0.203: U9.M9 140.38,59.24 v1(141,59.87) 141.26,60.12 141.26,61.01 140.75,61.52 R146.2 R147.1
M_B_BG#1_2: length 9.3
  BOTTOM w0.203: U25.M9 140.38,51.85 141.99,50.24 142.7,50.24 143.32,49.62 v1(143.67,49.62) 145.11,49.62 145.84,50.36 146.76,50.36 147.05,50.65 R533.1 R535.2
