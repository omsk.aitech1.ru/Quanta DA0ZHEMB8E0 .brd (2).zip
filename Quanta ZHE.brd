# Allegro board Quanta ZHE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.5VA: length 2.3
  TOP w0.152: U16.40 175.82,18.99 175.75,19.06 175.39,19.06
  TOP w0.254: 174.27,19.35 174.57,19.06 175.39,19.06
  vias: v1(173.64,20.83)
+1.8V: length 265.2
  TOP w0.508: v1(162.06,78.76) 162.47,79.17 R56.2 R57.1 ; R7.1 28.62,96.45 28.86,96.7 v1(29.34,96.7) ; v1(111.16,84.38) 111.16,86.47 PR1.1 ; R197.1 R198.1 58.06,51.49 v1(59.09,50.47) 59.77,49.78 v1(60.75,49.78) 60.75,51.13 R202.1 ; v1(33.15,81.89) 34.09,81.89 35.69,83.49 47.26,83.49 50.48,86.71 56.24,86.71 57,85.95 v1(57,85.62)
  IN2 w0.508: v1(29.34,96.7) 30.23,95.81 30.63,95.81 33.05,93.38 33.05,88.7 33.31,88.44 33.31,86.54 33.05,86.28 33.05,81.99 v1(33.15,81.89) 33.15,80.99 32.35,80.19 28.26,80.19 24.95,76.87 21.88,76.87 21.37,76.36 21.37,71.78 22.23,70.92 22.23,66.6 23.73,65.11 23.73,63.47 26.73,60.47 v1(26.73,59.21) ; v1(57,85.62) 60.04,85.62 60.7,86.28 64.68,86.28 65.21,86.82 68.79,86.82 71.68,89.71 75.84,89.71 76.86,88.69 85.1,88.69 85.8,87.99 88.19,87.99 88.81,87.37 91.12,87.37 92.08,86.41 96.53,86.41 98.95,88.83 104.6,88.83 106.12,87.3 109.12,87.3 110.52,85.9 110.52,85.01 v1(111.16,84.38) 113.68,84.38 114.69,83.36 115.87,83.36 116.21,83.02 124.19,83.02 125.75,81.46 141.01,81.46 143.16,79.3 146.33,79.3 147.09,80.06 147.91,80.06 148.55,79.42 161.4,79.42 v1(162.06,78.76)
  IN3 w0.508: v1(26.73,59.21) 27.13,59.21 28.87,60.95 29.51,60.95 30.84,59.61 41.91,59.61 43.44,61.14 45.54,61.14 45.81,61.4 46.96,61.4 47.32,61.76 47.75,61.76 48.91,60.59 48.91,58.21 50.33,56.8 50.33,55.32 51.61,54.04 51.61,49.14 50.47,48 50.47,46.81 50.87,46.42 50.87,45.48 v1(50.83,45.44)
  BOTTOM w0.508: v1(111.16,84.38) 113.45,84.38 R409.2 ; PQ19.1 23.4,59.23 23.78,58.85 26.37,58.85 v1(26.73,59.21) ; v1(60.75,49.78) 60.75,48.45 57.66,45.36 50.91,45.36 v1(50.83,45.44)
+1.8V_EMMC: length 17.2
  TOP w0.508: C184.2 C186.2 64.16,50.35 v1(63.54,49.73) v1(62.98,50.3) 62.15,51.13 R202.2 ; C164.1 C173.2 63.91,56.43 C163.1 63.15,56.06 62.66,55.56 v1(62.66,55.24)
  IN2 w0.508: v1(62.66,55.24) 62.21,54.8 62.21,52.4 62.02,52.21 62.02,51.26 v1(63.54,49.73)
  BOTTOM w0.229: U26.M4 U26.N4 U26.P3 64.38,50.24 64.05,49.91
+1.8V_S5: length 419.2
  TOP w0.254: Q20.5 76.87,10.72 76.69,10.9 76.03,10.9 75.85,10.72 v1(75.85,10.34)
  TOP w0.305: R269.2 21.1,42.24 U10.1
  TOP w0.381: R136.2 66.84,62.01 R149.2 67.46,61.52 R137.2
  TOP w0.508: v1(65.95,50.6) 66.06,50.71 R199.2 ; v1(84.64,71.19) 84.64,70.66 84.73,70.66 R100.1 ; v1(86.52,10.84) 86.4,10.96 R360.2 ; R108.1 86.63,68.13 R104.1 84.75,68.24 83.85,69.15 83.08,69.15 81.9,70.33 v1(80.09,70.33) ; v1(99.63,79.04) 99.63,79.12 100.37,79.86 R65.2 101.02,80.06 101.28,79.8 R61.2 102.29,79.8 103.01,79.07 v1(103.01,78.19) 103.01,77.68 R75.2 ; v1(89.92,83.95) 89.92,84.65 R37.2 ; v1(45.42,42.82) 45.14,43.1 R257.1 ; v1(151.34,10.84) C317.1 PR108.1 ; R164.2 73.18,59.36 R157.2 v1(72.55,60.25) ; R106.1 80.29,70.14 v1(80.09,70.33) ; v1(55.25,58.25) 55.05,58.25 54.65,58.66 R169.1 54.31,58.96 54.83,59.49 55.53,59.49 55.79,59.23 ; R166.2 v1(70.49,59.1) ; R141.2 78.13,62.91 78.52,63.3 78.52,63.7 78.05,64.17 76.09,64.17 v1(76.08,64.18) ; v1(80.09,70.33) 78.7,70.33 76.66,68.29 73.97,68.29 73.56,67.88 R109.1 ; R111.1 78.78,67.23 v1(79.53,67.23) R112.1 ; v1(26.14,96.41) 26.19,96.45 R6.1 ; v1(92.87,78.14) 92.74,78.14 92.48,77.88 R72.2 ; R130.2 72.04,63.55 71.79,63.8 v1(71.79,64.18) ; R51.2 91.78,81.33 91.15,81.96 R46.2 90.58,81.7 v1(90.58,81.2) ; v1(70.26,63.68) 69.12,63.68 68.35,62.91 R137.2 ; R270.2 v1(22,41.96) R269.2 ; R140.2 v1(74.45,62.41) ; v1(43.16,36.55) 43.39,36.78 43.7,36.78 R281.1 44.88,37.45 45.19,37.77 Q12.2 ; v1(77.12,66.04) 77.43,66.34 R117.2 ; R156.2 v1(70.52,60.25) ; R152.2 v1(74.45,61.39)
  IN1 w0.508: v1(76.77,77.77) 76.77,79.06 78.26,80.55 78.26,84 v1(77.38,84.89) ; v1(44.99,62.94) 44.99,62.62 43.32,60.95 v1(43.32,59.87) 43.32,57.68 44.3,56.7 v1(44.3,56.25) ; v1(103.01,78.19) 103.01,77.06 104.81,75.26 104.81,68.88 105.34,68.35 105.34,67.76 105.75,67.34 112.57,67.34 113.24,66.67 v1(114.61,66.67)
  IN2 w0.508: 65.21,56.79 56.71,56.79 v1(55.25,58.25) 55.1,58.41 55.1,61.57 54.64,62.03 54.01,62.03 53.22,62.81 45.12,62.81 v1(44.99,62.94) ; v1(24.16,51.23) 24.16,51.99 22.43,53.72 v1(22.43,61.67) ; v1(22,41.96) 22.27,41.96 22.64,42.33 22.64,42.59 23.27,43.23 25.51,43.23 26.14,42.59 30.89,42.59 32.16,41.32 35.97,41.32 36.74,40.56 37.62,40.56 38.77,39.42 40.47,39.42 43.16,36.73 ; v1(43.16,36.55) 43.16,36.73 ; 43.16,36.73 43.16,37.44 43.19,37.47 43.19,37.52 43.82,38.15 43.82,38.99 44.42,39.59 44.42,42.14 45.1,42.82 v1(45.42,42.82)
  IN3 w0.508: v1(151.34,10.84) 152.2,11.71 152.2,12.79 150.71,14.28 146.88,14.28 145.24,15.92 141.51,15.92 141.03,15.44 139.61,15.44 138.83,16.22 138.83,16.93 139.02,17.12 139.02,18.9 138.13,19.78 133.08,19.78 132.26,18.97 124.91,18.97 124.38,18.44 124.38,12.8 123.44,11.86 121.5,11.86 120.61,10.97 112.06,10.97 111.3,10.21 86.77,10.21 86.52,10.46 v1(86.52,10.84) 84.07,10.84 83.13,9.9 81.24,9.9 v1(80.8,10.34) 79.03,10.34 78.39,9.7 76.11,9.7 75.85,9.96 v1(75.85,10.34) 75.3,10.34 74.76,9.79 58.99,9.79 58.74,10.04 56.19,10.04 55.47,9.32 53.85,9.32 51.9,11.28 47.32,11.28 44.99,13.6 44.99,18.97 43.85,20.12 40.33,20.12 37.64,22.8 37.64,23.31 38.64,24.31 38.64,24.96 42.07,28.39 42.07,29.25 42.97,30.15 42.97,33.49 43.16,33.68 v1(43.16,36.55) ; v1(26.14,96.41) 25.52,96.41 24.54,95.44 24.54,93.42 23.91,92.78 23.91,90.1 24.73,89.28 25.86,89.28 26.63,88.52 26.63,82.78 ; v1(45.42,42.82) 44.41,43.84 44.41,45.01 43.09,46.33 43.09,46.67 42.1,47.65 41.05,47.65 39.3,49.4 39.3,52.96 39.94,53.59 39.94,54.9 v1(39.28,55.56) 39.28,55.57 40.55,56.84 43.71,56.84 v1(44.3,56.25)
  BOTTOM w0.305: 42.33,59.35 42.69,58.99 U23.1
  BOTTOM w0.381: R514.2 v1(70.49,59.1) R166.2 ; R152.2 v1(74.45,61.39) ; R444.2 99.63,78.47 v1(99.63,79.04) ; R476.2 79.91,70.14 v1(80.09,70.33) 80.3,70.53 R475.2 ; R511.2 76.03,60.07 v1(76.49,60.07) ; R156.2 v1(70.52,60.25) ; v1(73.18,64.18) 74.07,65.07 R489.2 ; R491.2 76.23,64.33 v1(76.08,64.18) ; R140.2 v1(74.45,62.41) ; R157.2 v1(72.55,60.25)
  BOTTOM w0.508: R400.2 91.47,86.54 91.09,86.16 U21.8 88.93,86.16 88.6,85.82 88.6,85.48 89.92,84.16 v1(89.92,83.95) 89.92,83.49 89.96,83.45 C350.1 89.96,82.98 89.41,82.43 89.41,80.93 R434.1 ; v1(76.77,77.77) R447.2 ; R112.1 v1(79.53,67.23) R482.2 ; R525.2 44.11,56.44 v1(44.3,56.25) ; 42.33,59.35 42.33,59.64 42.55,59.87 v1(43.32,59.87) ; v1(39.28,55.56) 39.38,55.67 R526.2 ; R527.2 68.6,55.8 68.35,55.55 v1(67.98,55.55) 67.98,56.19 68.73,56.95 R523.2 ; R492.2 114.37,66.43 v1(114.61,66.67) ; R403.2 100.17,87.17 v1(100.09,87.25) 100,87.17 R402.2 ; v1(44.99,62.94) 45.14,62.79 PR202.1 ; R407.2 77.38,84.88 v1(77.38,84.89) ; v1(71.79,64.18) R487.2 ; v1(24.16,51.23) 21.24,48.31 21.24,42.21 21.5,41.96 v1(22,41.96) ; R495.2 77.12,65.21 v1(77.12,66.04) 77.17,66.09 R485.1 77.75,65.84 78.26,65.34 R496.1 ; R501.2 v1(69.76,62.41)
  vias: v1(23.77,67.63) v1(24.21,81.3) v1(24.42,67.61) v1(24.85,81.3) v1(25.18,67.61) v1(25.48,81.3) v1(60.18,89.63) v1(60.66,88.14) v1(60.84,89.63) v1(61.5,89.63) v1(61.5,84.63) v1(62.14,84.63) v1(62.16,89.63) v1(62.77,84.63) v1(67.52,54.79) v1(106.84,83.87)
+1.24V_S5:
  vias: v1(115.35,65.07) v1(120.91,63.32) v1(121.24,63.9) v1(121.39,62.89) v1(121.72,63.47) v1(122.13,62.89) v1(122.36,63.55)
+2.5V: length 9.9
  TOP w0.508: PQ10.1 114.15,34.09 114.15,34.09 PR79.1 v1(113.06,33.02) 115.04,31.04 116.17,31.04 116.67,30.54 116.67,30.01 115.92,29.26 R301.2
+2.5V_SUS: length 88.4
  TOP w0.381: 142.4,59.87 142.4,58.69 U9.R9 ; U9.B1 132.4,51.91 132.48,51.83 132.48,51.28 131.43,50.23 131.43,48.85 C198.2 ; C238.1 132.49,31.8 132.38,31.91 U13.B1 ; C222.2 146.77,40.44 145.54,41.67 142.92,41.67 142.6,41.35 142.6,40.71 U13.R9
  TOP w0.508: 116.11,32.05 118.32,29.84 v1(118.32,29.56) ; v1(147.73,35.23) 148.09,35.23 149.69,36.82 149.69,37.84 148.84,38.69 147.92,38.69 147.47,39.14 C224.2 C222.2 ; C198.2 129.86,49.76 v1(129.5,49.76) 129.5,47.24 130.59,46.15 C197.2 ; v1(142.55,61.01) 142.55,61.51 142.93,61.89 C131.1 C132.1 144.18,61.64 142.4,59.87 ; C238.1 C239.1 v1(133.51,31.32)
  IN2 w0.508: 142.37,60.27 143.9,60.27 144.3,59.87 148.24,59.87 150.46,57.64 150.46,54.34 149.5,53.38 147.95,53.38 146.36,51.79 v1(146.36,51.76)
  BOTTOM w0.381: U30.R9 142.82,34.09 142.82,32.78 143.76,31.84 143.76,31 143.42,30.66 C442.1 v1(143.16,31.5) ; v1(133.33,61.47) 133.75,61.89 C397.1 C398.1 135.03,61.39 134.3,60.65 133.46,60.65 132.53,59.72 132.53,58.46 U25.B1 ; v1(146.36,51.76) 146.36,52.68 146.74,53.06 C413.2 C414.1 147.2,51.79 146.6,51.18 145.63,51.18 144.77,50.32 143.61,50.32 142.93,51 142.93,51.76 U25.R9 ; U30.B1 132.57,40.72 132.57,41.11 132.18,41.5 131.72,41.5 130.44,40.22 130.44,39.88 129.09,38.53 C432.1 C430.1 129.29,39.55 v1(129.34,39.6)
  vias: v1(113.82,26.72) v1(113.82,26.08) v1(116.24,18.72) v1(116.87,18.72) v1(118.29,28.93) v1(118.65,18.34) v1(118.93,28.9) v1(118.95,29.56)
+3V: length 322.7
  TOP w0.102: C156.1 60.43,58.52
  TOP w0.508: R26.1 25.35,86.21 v1(25.27,86.21) ; v1(117.76,23.42) 117.43,23.09 117.43,20.85 116.86,20.28 C273.1 116.12,20.28 115.82,19.98 C275.1 R324.1 R323.1 ; R58.1 164.5,79.04 v1(164.24,78.79) ; v1(54.26,14.15) 54.76,13.65 R351.2 ; v1(54.26,14.15) 53.76,13.65 R350.2 ; v1(54.26,14.15) 54.76,14.65 R343.2 ; v1(54.26,14.15) 53.76,14.65 R342.2 ; v1(107.32,18.72) 107.32,16.04 108.3,15.06 108.3,7.48 108.63,7.15 PR114.1 ; R310.2 v1(116.11,28.24) ; R221.1 23.78,48.88 v1(24.16,49.26) ; v1(51.59,8.3) 51.98,8.69 R371.2 R383.2 ; R285.1 19.3,37.17 v1(19.21,37.26) ; 115.6,77.14 115.86,77.39 C58.1 ; 115.6,77.14 115.48,77.01 R81.1 ; 115.6,77.14 v1(115.48,77.14) ; v1(159.26,69.89) 159.26,67.5 R115.2 ; v1(181.77,10.46) 181.27,10.96 R362.2 ; v1(186.98,13.77) 186.98,15.17 R341.1 ; R262.2 27.33,43.87 26.58,44.63 v1(26.58,44.75) 26.83,45.01 R234.2 ; R173.1 59.99,57.18 v1(60.49,57.68) 60.48,57.69 60.48,58.46 C156.1 ; R302.2 v1(17.18,29.01) ; R336.2 104.72,16.98 105.44,17.7 v1(105.44,18.64) ; U34.5 60.2,60.37 59.98,60.15 59.98,60 C542.1 59.98,58.96 60.43,58.52 ; R337.1 v1(101.6,18.72) ; R333.1 v1(92.74,18.72)
  IN1 w0.508: v1(19.21,37.26) 17.81,35.86 17.81,33.1 17.4,32.69 16.59,32.69 16.19,32.28 16.19,30 v1(17.18,29.01)
  IN2 w0.508: 116.92,89.18 116.9,89.15 115.79,89.15 115.61,88.97 107.15,88.97 106.61,88.44 v1(106.61,88.39) ; 116.92,89.18 116.92,89.02 118.4,87.54 118.4,85.39 119.03,84.76 122.21,84.76 122.51,84.45 124.03,84.45 125.64,82.85 129.96,82.85 130.47,82.35 141.37,82.35 143.53,80.19 145.96,80.19 146.73,80.95 148.28,80.95 148.91,80.31 163.23,80.31 164.24,79.3 v1(164.24,78.79) ; 116.92,89.18 v1(116.92,89.38) ; 52.23,65.16 52.1,65.28 52.1,67.23 50.13,69.2 ; 52.23,65.16 52.9,65.16 54.63,63.42 54.65,63.42 55.99,62.08 55.99,58.77 57.08,57.68 v1(60.49,57.68) ; 52.23,65.16 v1(51.15,65.16) ; v1(20.61,58.7) 21.06,58.24 21.06,51.18 v1(20.45,50.57) 20.71,50.32 23.11,50.32 v1(24.16,49.26) 25.18,48.25 25.18,46.89 26.58,45.49 v1(26.58,44.75) ; 50.13,69.2 50.13,70.43 v1(50.43,70.73) ; 50.13,69.2 49.77,68.83 49.77,66.56 48.43,65.23 43.27,65.23 42.73,65.76 41.07,65.76 40.34,65.03 40.34,63.8 39.83,63.3 38.94,63.3 38.13,64.11 v1(38.13,66.92)
  IN3 w0.508: v1(25.27,86.21) 24.67,86.21 22.37,83.91 22.37,82.11 20.73,80.47 20.73,71.16 20.29,70.72 20.29,66.26 19.44,65.41 19.44,59.3 20.05,58.7 v1(20.61,58.7) ; 170.44,7.67 172.87,7.67 175.28,10.08 180.5,10.08 180.88,10.46 v1(181.77,10.46) 181.77,11.66 183.12,13 184.61,13 185.38,13.77 v1(186.98,13.77)
  BOTTOM w0.254: R454.1 115.09,76.5 115.48,76.88 v1(115.48,77.14) 115.35,77.27 Q32.2 Q32.5 115.35,80.85 115.36,80.86 115.36,81 115.58,81.22 115.62,81.22 115.99,81.59 R419.1
  BOTTOM w0.508: R619.2 54.35,17.08 54.21,16.94 54.21,14.53 54.22,14.15 v1(54.26,14.15) 53.82,13.7 53.1,13.7 52.15,12.75 52.15,12.17 52.15,8.86 v1(51.59,8.3) ; v1(158.78,60.63) 158.66,60.5 PR218.1 ; v1(162.08,69.9) R472.1 ; U27.4 55.97,53.43 56.63,53.43 57.54,54.35 57.54,56.89 58.5,57.85 60.32,57.85 v1(60.49,57.68) ; v1(20.45,50.57) 19.34,49.45 19.34,37.39 v1(19.21,37.26) 19.96,36.51 R551.1 ; v1(38.13,66.92) 37.74,67.31 PR175.1 32.51,67.49 30.45,65.43 28.28,65.43 27.72,64.87 27.72,58.92 26.76,57.96 21.34,57.96 v1(20.61,58.7) ; PR151.1 50.29,71.47 50.29,70.88 v1(50.43,70.73) ; v1(51.15,65.16) 50.5,65.16 PR185.2 ; R393.2 104.05,89.7 105.13,88.62 105.13,88.3 105.54,87.89 106.13,87.89 106.54,88.3 106.54,88.32 v1(106.61,88.39) 106.61,89.44 104.05,92 99.22,92 98.84,91.62 98.84,90.73 ; PR244.1 v1(139.48,25.96)
  vias: v1(20.29,16.11) v1(20.29,15.29) v1(138.36,20.8) v1(139.05,20.8) v1(149.77,62.66) v1(150.91,77.27) v1(151.54,77.27) v1(151.95,62.96) v1(151.95,62.33) v1(152.27,77.26) v1(152.58,62.96) v1(152.58,62.33) v1(152.91,77.29) v1(154.72,42.44) v1(164.12,12.83) v1(164.12,12.19) v1(166.91,76.25) v1(169.07,78.54) v1(169.7,78.54)
+3V_EC: length 7.5
  TOP w0.203: U14.11 21.84,34.38 21.71,34.51 21.71,34.75 21.24,35.22
  TOP w0.305: v1(18.07,37.39) 18.1,37.35 R285.2 18.1,36.05 R286.2 19.6,34.85 C229.1 21.24,35.22
+3V_EMMC:
  vias: v1(61.12,55.04) v1(61.5,54.2) v1(61.47,53.54) v1(62.91,54.25) v1(63.89,54.02)
+3V_HDMI: length 25.7
  TOP w0.178: v1(123.48,81.81) 123.48,81.84 123.39,81.92 U6.1 ; 117.25,87.78 117.47,87.57 U6.24
  TOP w0.254: R43.1 126.14,83.11 126.65,82.6 126.65,80.95 126.25,80.55 123.88,80.55 123.48,80.95 v1(123.48,81.81) ; R27.1 113.82,88.48 114.16,88.82 116.53,88.82 116.87,88.49 116.87,88.17 117.25,87.78
  IN1 w0.254: v1(123.48,81.81) 122.56,81.81 122.46,81.71 117.25,81.71 114.97,79.42 112.81,79.42 v1(112.43,79.04)
  vias: v1(114.08,75.23)
+3V_LDO_EC: length 62.5
  TOP w0.508: v1(45.42,41.83) 45.17,41.83 44.91,42.09 R268.2 ; D17.1 17.05,31.9 v1(17.15,31.8) 17.55,31.8 R291.2 ; R311.1 19.37,27.48 v1(18.65,27.48) ; R273.2 R266.2 47.12,42.72 v1(46.87,42.47) ; R259.2 35.59,43.17 34.96,43.17 34.45,42.65 v1(34.45,42.58) 34.18,42.85 R258.2 ; R267.2 31.27,43.73 R250.2 30.95,43.86 v1(30.57,44.25) ; R247.1 v1(45.5,44.12)
  IN1 w0.508: v1(20.99,40.05) 20.5,39.57 20.5,37.3 18.7,35.49 18.7,32.73 17.77,31.8 17.28,31.8 ; v1(18.65,27.48) 18.47,27.66 18.47,30.6 17.28,31.8 ; 17.28,31.8 v1(17.15,31.8)
  IN2 w0.508: v1(45.42,41.83) 46.23,41.83 v1(46.87,42.47) 46.87,42.75 v1(45.5,44.12) 44.74,44.12 43.72,43.1 35.69,43.1 35.54,43.26 34.86,43.26 34.45,42.85 v1(34.45,42.58) 32.23,42.58 v1(30.57,44.25) 29.81,43.48 26.58,43.48 25.31,44.75 22.64,44.75 20.99,43.1 v1(20.99,40.05)
+3V_MINI1_VDD:
  vias: v1(16.64,15.57) v1(16.64,14.91) v1(16.62,14.25) v1(18.45,25.55) v1(19.13,25.55) v1(19.21,17.88) v1(19.62,18.41) v1(20.4,18.13) v1(26.44,15.4) v1(26.83,15.92) v1(29.7,21.66) v1(30.39,20.9) v1(40.55,28.69) v1(41.31,28.69) v1(41.94,11.23) v1(47.66,12.19)
+3V_RTC: length 210.3
  TOP w0.508: v1(70.77,16.18) v1(70.77,12.24) 70.77,10.18 70.52,9.93 D29.3 68.34,11.47 R358.1 R357.1 R356.2 R367.1 ; v1(92.27,96.06) 92.27,95.51 94.62,93.17 97.54,93.17 98.48,92.23 98.48,81.61 R52.2 98.84,81.59 99.11,81.32 102.36,81.32 R92.1
  IN2 w0.508: v1(92.27,96.06) 92.22,96.11 91.01,96.11 90.63,95.74 90.63,94.72 89.18,93.27 70.05,93.27 67.15,90.37 63.79,90.37 63.69,90.27 59.66,90.27 58.69,89.3 53.36,89.3 46.48,82.42 37.15,82.42 33.14,78.41 29,78.41 25.71,75.12 25.71,71.25 26.51,70.45 26.51,68.45 26.13,68.07 26.13,62.32 29.73,58.72 32.42,58.72 32.63,58.51 38.89,58.51 42.37,55.04 44.18,55.04 44.48,55.34 45.96,55.34 47.02,54.28 47.02,50.6 48.94,48.68 48.94,46.77 49.94,45.77 49.94,44.37 50.2,44.12 50.2,37.64 51.29,36.55 v1(53.07,36.55)
  IN3 w0.254: 52.1,27.86 52.1,21.26
  IN3 w0.508: v1(70.77,16.18) 70.77,17.45 70.06,18.15 68.71,18.15 66.66,20.21 60.69,20.21 60.04,20.86 52.5,20.86 52.1,21.26 ; 52.1,27.86 51.68,28.29 51.68,32.18 53.12,33.62 53.12,36.5 v1(53.07,36.55)
+3V_RTC_1: length 99.9
  TOP w0.508: v1(71.89,7.95) D29.1 70.54,8.65 70.29,8.9 v1(69.65,8.9) ; v1(155.73,3.86) 155.99,3.61 R387.2
  IN3 w0.508: v1(69.65,8.9) 69.75,8.81 83.29,8.81 83.8,9.32 120.22,9.32 121.87,10.97 124.79,10.97 126.32,12.5 132.67,12.5 136.74,8.43 149.39,8.43 150.94,6.88 156.24,6.88 157.51,5.61 157.51,4.37 157,3.86 v1(155.73,3.86)
+3V_S5: length 277.8
  TOP w0.305: R216.2 20.6,47.16 21.1,46.66 U10.6
  TOP w0.508: v1(106.31,86.42) 107.08,85.65 C20.2 ; R216.2 20.6,47.67 20.61,47.67 20.61,47.83 v1(20.38,48.06) ; v1(100.45,62.56) 100.61,62.4 C139.1 ; R284.1 50.21,36 v1(49.94,35.74) ; v1(35.32,55.66) 38.24,55.66 v1(38.99,56.41) 40.85,58.27 45.57,58.27 46.56,57.28 51.24,57.28 51.47,57.51 52.48,57.51 52.86,57.13 v1(52.86,56.56) 52.86,56.31 53.37,55.8 54.07,55.8 R174.1 ; R344.2 73.18,15.17 72.8,15.54 72.8,16.94 73.44,17.58 86.27,17.58 v1(87.41,18.72) ; v1(34.96,81.48) 36.07,82.6 47.63,82.6 50.78,85.75 v1(54.92,85.75) ; R80.1 23.54,74.62 v1(22.26,74.62) ; v1(17.18,34.64) 17.38,34.85 R286.1 ; v1(40.86,17.21) 40.86,17.13 41.31,16.69 v1(41.99,16.69) 43.68,16.69 44.23,16.14 44.23,13 v1(43.97,12.75)
  IN1 w0.508: v1(100.62,73.58) 101.22,73.58 101.34,73.46 101.34,68.25 v1(101.97,67.63) ; v1(79.45,76.41) 78.72,77.14 78.72,79.75 79.15,80.19 79.15,84.48 77.32,86.31 v1(77.07,86.31)
  IN2 w0.508: 76.83,87.13 77.48,87.78 84.74,87.78 v1(86.77,85.75) 88.22,85.75 88.96,86.49 90.74,86.49 91.7,85.52 97.26,85.52 99.22,87.48 v1(99.22,87.81) 99.35,87.94 104.23,87.94 105.76,86.42 v1(106.31,86.42) 107.47,86.42 109.05,84.83 109.05,83.42 ; 76.83,87.13 75.14,88.82 72.05,88.82 68.75,85.52 65.86,85.52 65.52,85.18 64.91,85.18 64.7,85.39 61.07,85.39 60.41,84.73 55.94,84.73 v1(54.92,85.75) ; 76.83,87.13 77.07,86.89 v1(77.07,86.31) ; v1(34.96,81.48) 32.77,79.3 28.63,79.3 25.31,75.98 23.61,75.98 v1(22.26,74.62) ; v1(100.62,73.58) 100.62,76.27 101.51,77.16 102.93,77.16 106.71,80.95 107.3,80.95 107.6,81.25 107.6,82.93 108.09,83.42 109.05,83.42 ; 109.05,83.42 113.38,83.42 114.32,82.47 115.5,82.47 115.84,82.13 116.33,82.13 116.82,81.63 117.05,81.63 ; v1(52.86,56.56) 52.86,56.18 53.82,55.23 53.82,48.1 56.42,45.5 56.42,38.23 53.52,35.33 50.35,35.33 v1(49.94,35.74)
  IN3 w0.089: v1(101.97,67.63) 101.97,67.61
  IN3 w0.508: 101.97,67.61 101.09,66.73 101.09,65.67 100.45,65.03 v1(100.45,62.56)
  BOTTOM w0.229: U22.AJ21 v1(100.45,62.56) U22.AG21
  BOTTOM w0.305: 39.54,58.99 U23.6
  BOTTOM w0.381: R420.1 87.92,81.59 R433.1 ; R458.2 79.91,75.95 79.45,76.4 v1(79.45,76.41) ; R397.2 99.23,87.95 99.22,87.94 v1(99.22,87.81) ; v1(106.31,86.42) 104.17,86.42 103.67,85.91 99.47,85.91 R405.2
  BOTTOM w0.508: v1(99.22,87.81) 99.59,87.81 99.73,87.94 101.37,87.94 R398.2 ; 39.54,58.99 38.64,58.09 38.64,56.75 v1(38.99,56.41) ; v1(49.94,35.74) 50.07,35.61 50.07,33.58 49.56,33.07 47.4,33.07 45.37,31.04 45.37,25.83 44.82,25.28 44.82,23.58 45.81,22.59 v1(46.76,22.59) ; R420.1 87.9,81.85 87.9,84.63 v1(86.77,85.75) ; R617.2 43.46,12.23 v1(43.97,12.75) ; v1(35.32,55.66) 36.12,55.66 R528.1 ; v1(136.05,75.23) 135.8,74.98 PR143.1 ; PR220.1 18.73,56.94 v1(18.49,57.17)
  vias: v1(19.31,11.73) v1(19.31,11.1) v1(37.95,17.3) v1(88.04,18.72) v1(88.68,18.72) v1(108.24,18.72) v1(108.87,18.72) v1(109.51,18.72) v1(110.14,18.72) v1(147.61,74.47) v1(148.24,74.47) v1(149.77,74.47) v1(150.4,74.47) v2(24.52,16.66) v2(25.13,17.19)
+3VPCU: length 341.1
  TOP w0.254: v1(37.6,21.39) 38.13,21.39 38.39,21.64 RP1.10
  TOP w0.305: RP1.5 40.93,19.1
  TOP w0.508: R126.2 155.26,64.07 155.91,63.42 155.91,63.27 v2(156.24,62.94) 156.55,63.24 156.55,63.63 157.16,64.23 R125.1 ; v1(149.48,13.65) 149.21,13.65 148.97,13.89 PR97.2 ; C126.2 46.58,61.69 47.81,61.69 48.79,60.71 C147.2 48.79,59.6 48.04,58.85 v1(47.02,58.85) ; 73.82,88.31 73.82,91.86 R12.2 ; PR87.2 139.1,15.92 v1(139.73,16.56) 139.15,17.14 139.15,19 138.44,19.71 133.15,19.71 132.29,18.85 125.38,18.85 125.13,19.1 v1(125.13,19.61) ; v1(44.9,11.47) 45.12,11.69 45.12,16.51 ; v1(186.72,20.75) 186.72,20.18 R331.2 ; 53.75,40.94 52.84,41.86 50.36,41.86 R273.1 ; 53.75,40.94 53.75,36.11 48.04,30.39 48.04,22.4 47.53,21.89 46.49,21.89 45.22,23.16 43.34,23.16 42.7,22.53 ; 53.75,40.94 54.45,41.64 54.45,46.51 51.26,49.71 50.58,49.71 v1(50.2,50.09) ; D29.2 68.59,8.58 v1(68.59,8.92) 68.74,9.07 68.74,9.8 68.32,10.22 R368.1 ; v1(65.26,85.82) 65.26,88.44 66.95,90.13 R13.2 R8.2 66.95,94.91 67.6,95.55 68.6,95.55 R5.2 ; PR89.2 v1(146.97,16.56)
  IN1 w0.508: v1(74.24,86.73) 75.06,85.9 75.06,84.19 76.36,82.89 76.36,82.41 v1(76.35,82.4) ; v2(157.16,62.89) 158.93,62.89 160.08,61.75 160.08,58.04 160.47,57.64 160.47,51.07 159.54,50.14 159.54,49.53 158.82,48.81 156.74,48.81 155.33,47.4 155.33,38.89 153.87,37.43 v1(152.77,37.43) 152.77,36.76 150.55,34.54 150.55,32.86 146.95,29.26 146.95,26.03 147.5,25.47 147.86,25.47 148.27,25.07 148.27,22.3 147.81,21.84 147.81,20.14 146.97,19.3 v1(146.97,16.56)
  IN2 w0.508: v1(186.72,20.75) 187.23,20.24 187.23,15.04 186.09,13.89 185.45,13.89 184.69,13.13 183.17,13.13 182.02,11.99 177.6,11.99 176.66,12.93 172.55,12.93 171.48,11.86 v1(171.48,9.7) ; v1(25.53,22.27) 28.07,19.73 35.47,19.73 36.23,20.5 36.95,20.5 37.6,21.15 v1(37.6,21.39) ; v1(44.9,11.47) 44.61,11.18 44.61,10.58 45.32,9.87 48.03,9.87 48.88,9.02 60.02,9.02 60.79,8.26 67.92,8.26 v1(68.59,8.92)
  IN3 w0.508: v1(37.6,21.39) 40.39,18.59 v1(40.62,18.59) ; v1(146.97,16.56) 146.97,16.69 146.46,17.19 140.34,17.19 139.73,16.58 v1(139.73,16.56) ; v1(50.2,50.09) 49.75,50.53 49.75,52.97 48.93,53.8 48.93,56.22 47.02,58.13 v1(47.02,58.85)
  BOTTOM w0.508: v1(171.48,9.7) 171.48,8.94 173.51,6.91 173.51,3.73 173.13,3.35 160.74,3.35 159.42,4.67 159.42,6.4 159.16,6.65 157.51,6.65 156.62,7.54 155.99,7.54 155.48,8.05 155.48,9.83 151.66,13.65 v1(149.48,13.65) 145.44,13.65 144.69,14.4 141.38,14.4 139.73,16.05 v1(139.73,16.56) ; PR205.1 20.51,60.66 v1(20.48,60.63) ; v1(76.35,82.4) 76.36,82.38 76.36,80.97 75.97,80.58 R432.2 R438.2 ; v1(125.13,19.61) 119.75,19.61 117.34,17.2 99.49,17.2 PR258.2 ; v1(152.77,37.43) 152.05,38.15 PR231.1
  vias: v1(21.88,78.54) v1(42.53,21.59) v1(72.94,86.73) v1(73.6,86.73) v1(73.82,87.32) v2(132.37,65.33) v2(133.13,65.33) v2(133.89,65.33) v2(134.65,65.33) v2(153.73,62.38) v2(153.88,63.1) v2(154.46,62.28) v2(155.89,62.23) v2(156.67,62.23)
+3VPCU_EC: length 14
  TOP w0.203: U14.114 29.91,41.03 v1(29.75,41.2) ; 27.06,41.08 27.11,41.03 U14.121 ; 31.11,23.42 U14.50 ; 39.37,36.78 U14.92
  TOP w0.305: v1(39.95,37.18) 40.41,37.18 C226.1 C228.1 40.16,35.99 39.37,36.78 ; L7.1 41.95,28.5 v1(42.83,28.5) ; L4.2 v1(22,39.93) ; v1(30.79,22.17) 30.92,22.17 31.28,22.54 C271.1 31.4,22.81 31.11,23.1 31.11,23.42 ; v1(26.95,41.19) 27.06,41.08
  BOTTOM w0.305: v1(26.95,41.19) 27.61,41.19 C428.1 ; v1(29.75,41.2) 29.75,41.08 C429.1
  vias: v1(20.25,28.42) v1(21.11,28.52)
+3VPCU_ECPLL: length 3.7
  TOP w0.203: U14.127 24.71,40.92
  TOP w0.305: L4.1 C221.1 23.92,41.45 v1(24.29,41.45) 24.71,41.03 24.71,40.92
+5V: length 15.3
  IN2 w0.508: v1(140.93,3.67) 140.93,3.5 141.36,3.07 147.83,3.07 150.15,5.38 151.54,5.38 v1(152.18,4.75)
  BOTTOM w0.508: v1(140.93,3.67) 140.42,3.67 PR264.1 ; v1(24,30.63) 23.97,30.66 U31.2
  vias: v1(18.57,18.59) v1(18.57,17.32) v1(46.77,18.49) v1(118.52,90.19) v1(123.1,6.78) v1(123.73,6.78) v1(144.81,83.23) v1(152.43,82.47) v1(152.81,4.75) v1(153.45,4.75) v1(154.08,4.75) v1(154.08,4.11) v1(154.08,3.48) v1(154.21,6.53) v1(154.72,4.75) v1(154.72,4.11) v1(154.72,3.48) v1(165.51,76.25) v1(166.15,76.25) v1(167.8,25.07) v1(167.8,24.43) v1(167.8,23.8) v1(169.83,15.42) v1(170.47,15.42) v2(32.19,25.58) v2(32.93,25.58) v2(43.6,21.93) v2(44.1,21.36)
+5V_FAN1:
  vias: v1(21.24,30.43)
+5V_HDD1:
  vias: v1(48.93,10.46) v1(49.59,11.81) v1(49.56,10.46) v1(50.2,10.46)
+5V_KB:
  vias: v1(118.02,10.34) v1(118.65,10.34) v1(119.79,10.46)
+5V_PVDD:
  vias: v1(171.23,15.29)
+5V_S5: length 153.2
  TOP w0.508: 161.45,6.27 163.1,4.62 R389.1 ; C126.1 46.26,63.42 v1(46.29,63.45) 46.29,63.52 45.66,64.15 PR38.1 ; PR13.1 v1(54.26,72.19)
  IN1 w0.508: v1(54.26,72.19) 54.26,75.23 55.59,76.57 55.59,77.96 55.34,78.22 54.71,78.22 54.26,78.66 54.26,82.73 55.61,84.08 57.05,84.08 57.65,84.08 58.53,84.96 v1(58.53,86.64)
  IN2 w0.508: 91.52,89.74 91.5,89.71 77.09,89.71 76.73,90.08 76.21,90.6 71.15,90.6 68.26,87.7 64.84,87.7 64.31,87.17 60.33,87.17 59.8,86.64 v1(58.53,86.64) 54.46,86.64 47.58,79.75 38.26,79.75 35.72,77.21 35.72,75.68 34.28,74.24 32.85,74.24 29.88,71.27 v1(29.88,70.66) 29.88,66.2 32.38,63.7 37.28,63.7 v1(39.55,61.43)
  IN3 w0.508: v1(160.89,13.71) 160.59,14.02 157.27,14.02 156.81,14.47 156.81,14.64 154.68,16.77 154.68,16.98 151.16,20.5 148.36,20.5 147.85,21 143.47,21 143.21,21.26 143.21,25.84 145.35,27.97 v1(145.35,28.49) ; v1(46.29,63.45) 45.6,64.13 43.83,64.13 42.58,62.88 42.58,61.53 41.77,60.72 40.26,60.72 v1(39.55,61.43)
  BOTTOM w0.508: v1(29.88,70.66) 30.04,70.5 PR158.1 ; PR206.2 v1(39.55,61.43)
  vias: v1(91.85,91.11) v1(92.06,91.79) v1(92.49,91.11) v1(92.49,90.22) v1(92.69,91.79) v1(93.12,91.11) v1(93.33,91.79) v1(115.93,94.51) v1(115.86,92.89) v1(115.86,92.25) v1(116.49,92.89) v1(116.49,92.25) v1(116.57,94.49) v1(160.56,13.13) v1(160.56,12.5) v1(160.56,11.86) v1(160.56,11.23) v1(160.56,10.39) v1(161.2,13.13) v1(161.2,12.5) v1(161.2,11.86) v1(161.2,11.23) v1(164.75,55.17) v1(165.39,56.95) v1(165.39,55.17) v1(166.02,55.17)
+5VA: length 2.8
  TOP w0.203: C270.1 182.58,22.33 181.98,22.33 181.28,21.64 U16.26
  vias: v1(178.47,29.51)
+5VPCU: length 130.1
  TOP w0.102: PR8.2 148.24,76.62
  TOP w0.508: 148.24,76.62 147.77,76.62 146.89,75.74 v1(146.59,75.74) 142.3,75.74 142.25,75.69 141.2,75.69 140.54,76.35 140.54,78.46 140.85,78.76 140.85,81.68 142.4,83.23 PR4.1
  IN1 w0.508: v2(156.5,16.69) 153.02,16.69 152.6,17.1 152.6,17.99 151.92,18.67 151.92,24.15 149.19,26.88 149.19,28.17 151.63,30.6 157.5,30.6 157.92,30.17 161.32,30.17 162.31,31.17 162.31,34.39 161.73,34.98 161.73,36.7 162.31,37.29 162.31,44.9 162.8,45.39 v1(162.8,49.2) 165.11,51.51 165.11,52.5 166.63,54.02 166.63,56.03 v1(167.16,56.56)
  IN2 w0.508: v1(162.8,49.2) 162.59,49.4 162.59,55.8 161.3,57.1 161.3,57.84 161.32,57.87 161.32,65.84 160.57,66.6 v1(158.4,66.6)
  IN3 w0.508: v1(146.59,75.74) 150.1,75.74 150.73,75.11 151.57,75.11 152.11,75.65 161.21,75.65 161.78,75.08 164.9,75.08 167.32,72.66 167.32,69.49 165.09,67.26 164.27,67.26 163.56,66.54 163.56,65.63 164.01,65.17
  BOTTOM w0.508: PR222.2 166.66,57.06 v1(167.16,56.56) ; PR180.1 v1(158.4,66.6)
  vias: v1(152.94,11.23) v1(153.19,15.67) v1(158.78,10.08) v2(156.5,15.92) v2(157.26,16.56) v2(157.26,15.8) v2(157.51,14.78) v2(158.02,17.32) v2(158.02,16.56) v2(158.02,15.42) v2(158.66,15.8) v2(158.78,17.32) v2(158.81,16.53)
+12V_PANEL:
  vias: v1(170.34,70.28)
+A3VPCU: length 6.6
  TOP w0.203: 39.23,29.58 U14.74
  TOP w0.305: 39.23,29.58 39.97,28.83 39.97,28.55 40.54,27.99 L7.2 40.66,27.74 40.98,27.43 41.74,27.43 v1(42.45,26.72) 42.7,26.96 C257.1
+V3A_LX: length 3.4
  TOP w0.508: PR73.1 159.51,49.21 v2(158.82,49.9) 158.21,49.9 v1(157.89,50.21) 157.39,50.71 PC55.2
+V3A_LX_R: length 2.9
  TOP w0.127: v1(158.15,48.09) 158.31,48.25 PR73.2
  TOP w0.508: PR73.2 157.89,49.07 157.29,49.67 PC56.1
+V3A_OUT:
  vias: v1(152.31,57.71) v2(153.19,57.45) v2(153.19,56.69) v2(153.19,55.93) v2(153.19,55.17)
+V3A_VIN:
  vias: v1(155.23,40.05)
+V5P5A_LX: length 3.1
  TOP w0.508: PR81.1 163.74,29.41 v1(164.32,28.83) 164.32,28.29 164.74,27.87 PC67.2
+V5P5A_LX_R: length 2.6
  TOP w0.127: v1(163.74,33.58) 163.7,33.54 PC63.1
  TOP w0.508: PR81.2 163.74,31.79 163.7,31.82 PC63.1
+V5P5A_OUT:
  vias: v1(162.97,16.18) v2(163.1,18.97) v2(163.1,18.21)
+V5P5A_VIN:
  vias: v1(162.34,35.86) v1(162.34,35.23) v1(162.52,34.09)
+VCC_V3A: length 1.9
  BOTTOM w0.127: PC203.1 154.54,45.96 154.9,45.96 155.24,46.31 PU13.9
+VCC_V5P5A: length 3.4
  BOTTOM w0.203: PU14.11 165.08,30.49
  BOTTOM w0.254: PC219.1 166.55,28.75 v1(165.83,29.46) 165.83,30.03 165.59,30.28 165.3,30.28 165.08,30.49
+VCC_VCCGI: length 15.4
  TOP w0.381: C94.2 93.27,68.58 92.63,68.58 v1(92.61,68.56) ; C80.1 93.76,73.91 v1(93.42,73.57)
  BOTTOM w0.178: PR135.1 64.18,77.67 60.05,77.67 59.14,78.59 59.14,79.86 59.6,80.31 PL2.2
  BOTTOM w0.229: U22.P39 92.99,68.83 v1(92.61,68.56) U22.P41 ; U22.D37 93.79,73.25 v1(93.42,73.57) 92.99,73.25 U22.D39 ; U22.D33 95.77,73.59 v1(95.87,73.59) 96.05,73.59 U22.D31
  vias: v1(74.96,81.58) v1(80.4,82.88) v1(81.19,79.62) v1(81.42,83.87) v1(81.95,77.9) v1(82.05,83.87) v1(82.69,83.87) v1(82.71,79.62) v1(84.23,79.62) v1(84.23,78.54) v1(85.46,83.27) v1(85.76,79.62) v1(86.46,78.41) v1(86.52,77.78) v1(86.52,77.15) v1(86.77,83.62) v1(87.06,78.2) v1(87.15,77.14) v1(87.25,79.68) v1(87.48,77.73) v1(95,68.6) v1(95.11,66.91) v1(95.11,61.12) v1(95.87,66.9) v1(95.88,64.74) v1(95.87,62.56) v1(95.87,61.12) v1(96.64,66.18) v1(96.64,64.74) v1(96.63,62.57) v2(66.48,82.66) v2(66.48,81.93) v2(66.5,81.19) v2(66.53,80.45) v2(67.17,83.01) v2(67.17,82.25) v2(67.17,81.49) v2(67.22,80.76) v2(67.22,80.02) v2(67.85,82.73) v2(67.85,81.96) v2(67.85,81.2) v2(68.49,83.11) v2(68.53,82.33) v2(68.53,81.56) v2(69.25,83.11) v2(69.27,82.35) v2(71.11,82.35) v2(71.84,82.35) v2(72.58,82.35) v2(73.32,82.35) v2(74.05,82.35) v2(74.79,82.35) v2(75.53,82.35)
+VCCDDQ: length 12
  TOP w0.381: v1(90.67,57.23) 90.5,57.23 89.55,58.18 C155.2
  BOTTOM w0.152: v1(101.21,59.66) 100.84,60.03 U22.AP21 ; v1(101.21,59.66) 101.21,59.66 U22.AT21 ; v1(101.21,59.66) 101.21,59.66 U22.AT20 101.97,59.66 v1(101.97,59.66) ; U22.AT18 101.97,59.66 v1(101.97,59.66) ; v1(94.35,59.66) 93.98,60.03 U22.AP36 93.96,60.03 v1(93.59,59.66) ; v1(94.35,59.66) U22.AT35 ; v1(94.35,59.66) U22.AT36 v1(93.59,59.66) ; v1(93.59,59.66) 93.22,60.03 U22.AP38 ; v1(93.59,59.66) U22.AT38 ; v1(101.97,59.66) U22.AP18
  BOTTOM w0.254: U22.BA43 91,56.9 v1(90.67,57.23) ; U22.BA25 v1(99.63,56.54) ; U22.BA31 v1(95.93,56.54) ; U22.BA41 v1(91.55,56.54) ; U22.BA15 v1(104,56.54)
  BOTTOM w0.381: v1(104,56.54) 104.12,56.54 U22.BA13
  vias: v1(85.88,49.2)
+VCCIOA:
  vias: v1(83.18,55.79) v1(83.65,56.22) v1(96.64,59.66) v1(97.4,59.67) v1(98.58,60.37) v1(98.92,59.66)
+VCCRAM_1P05: length 1
  BOTTOM w0.229: U22.AF28 v1(98.16,64.01) U22.AF27
  vias: v1(91.98,63.3) v1(93.59,66.19) v1(93.59,65.46) v1(93.59,64.73) v1(93.59,64.02) v1(94.35,64.02) v1(94.35,64.74) v1(95.11,64.73) v1(121.67,74.47) v1(121.81,73.85) v1(122.3,75.11) v1(122.33,74.47) v1(122.45,73.85) v1(122.93,75.11) v1(122.99,74.47) v1(123.57,74.93)
+VCCRAM_1P05_FHV0: length 3
  TOP w0.508: v1(85.76,61.52) 86.1,61.86 R134.1 87.12,62.53 v1(87.32,62.73)
  BOTTOM w0.356: U22.AG51 87.68,63.13 87.32,62.77 v1(87.32,62.73)
+VCCRAM_1P05_FHV1: length 4
  TOP w0.508: R128.1 86.23,63.73 v1(86.34,63.62) 87.57,63.62 88.03,63.15 v1(88.03,62.73)
  BOTTOM w0.356: U22.AG49 88.39,63.13 88.03,62.77 v1(88.03,62.73)
+VCCRAM_1P05_FUSE: length 4.7
  TOP w0.508: v1(87.32,61.78) 85.79,60.25 84.45,60.25 R158.1
  BOTTOM w0.381: U22.AJ51 87.68,62.13 v1(87.32,61.78)
+VDD1_1P8: length 10.1
  TOP w0.508: R61.1 101.03,77.18 C67.2 101.03,76.45 100.86,76.28 100.86,74.34 101.13,74.08 C81.1 v1(101.51,73.23) 101.51,72.88 101.21,72.59 101.21,70.92 100.96,70.66 C87.1
  BOTTOM w0.229: U22.AJ23 v1(99.68,62.56) U22.AG23
  vias: v1(99.68,67.63) v1(100.45,67.63) v1(100.45,66.91)
+VDD2_1P24_AUD_ISH: length 17.7
  TOP w0.508: R129.2 116.27,63.3 C123.1 114.3,64.34 111.96,64.34 111.76,64.54 109.31,64.54 108.86,64.08 C117.1 v1(103.54,63.93) 103.26,64.21 103.26,64.41 103.03,64.65 102.92,64.65 102.11,65.46 v1(101.97,65.46)
  BOTTOM w0.229: U22.AC18 v1(101.97,65.46) U22.AC20
+VDD2_1P24_DSI_CSI: length 28.7
  TOP w0.508: R162.2 118.19,58.76 119.39,59.96 C151.1 120.11,60.66 v1(120.11,61.14) v1(120.11,62.85)
  IN1 w0.254: v1(105,56.64) 105,57.2 104.3,57.91 103.77,57.91 103.49,58.19 103.49,59.82 103.79,60.12 109.38,60.12 109.89,60.63 110.75,60.63
  IN1 w0.508: 110.75,60.63 115.53,60.63 117.75,62.85 v1(120.11,62.85)
  BOTTOM w0.254: U22.AW12 104.93,57.81 104.93,56.71 v1(105,56.64)
+VDD2_1P24_GLML: length 30.7
  TOP w0.508: v1(101.97,60.39) 102.11,60.39 102.47,60.03 108.49,60.03 C152.2 109.54,58.12 109.25,57.83 C166.2 115.74,57.04 116.24,57.53 v1(116.24,57.71) R161.2 ; v1(93.59,61.84) 93.14,62.29 C134.1
  IN2 w0.508: v1(101.97,60.39) 94.94,60.39 94.42,60.91 94.42,61.18 93.77,61.84 v1(93.59,61.84)
  BOTTOM w0.152: U22.AL36 v1(93.59,61.84) U22.AL38
  BOTTOM w0.254: U22.AM20 v1(101.97,60.39) U22.AP20
+VDD2_1P24_MPHY:
  vias: v1(101.21,64.74) v1(101.21,64.01) v1(101.97,64.73) v1(101.97,64.01) v1(110.78,66.09) v1(111.41,66.09) v1(112.05,66.09) v1(113.44,67.49)
+VDD2_1P24_PLL: length 1
  BOTTOM w0.254: U22.AL18 102.34,61.48 v1(101.98,61.12) 101.98,61.11 U22.AM18
  vias: v1(111.41,61.14)
+VDD2_1P24_USB2: length 17.3
  TOP w0.508: C125.1 101.94,62.52 v1(101.97,62.56) 102.86,62.56 103.62,63.32 v1(105.32,63.32) 107.76,63.32 108.04,63.04 110.73,63.04 C124.2 111.52,62.25 116.75,62.25 R143.2
  BOTTOM w0.254: U22.AJ20 v1(101.97,62.56) U22.AG18
+VDD2_1P24_VNNAON: length 1
  BOTTOM w0.229: U22.AA20 v1(101.97,66.18) U22.AA18
  vias: v1(105.32,65.84)
+VDDQ: length 55.3
  IN2 w0.508: v1(117.86,20.14) 118.22,20.5 134.53,20.5 135.16,19.86 140.75,19.86 v1(140.9,20.01)
  IN3 w0.508: v1(90.71,18.72) 91.85,17.58 110.57,17.58 112.38,19.39 114.98,19.39 115.73,20.14 v1(117.86,20.14)
  BOTTOM w0.508: v1(140.9,20.01) 141.37,20.49 PC225.1 PR253.1 ; R588.1 v1(90.71,18.72)
+VDDQ_VTT:
  vias: v1(113.44,18.85) v1(114.46,18.72) v1(115.09,18.72) v1(146.21,22.78) v1(146.21,22.15) v1(146.84,22.78) v1(146.84,22.15) v1(146.98,48.28) v1(150.95,43.99) v1(151.52,48.41) v1(151.62,45.36)
+VIN: length 8.8
  TOP w0.508: PR77.1 157.73,36.46 v2(157.13,35.86) ; C177.1 168.26,54.28 v1(169.28,55.29) ; v2(154.85,35.86) 154.5,36.21 PR78.1
  BOTTOM w0.14: PR164.2 24.73,69.98 24.73,72 24.93,72.21 PR150.2
  vias: v1(26.42,73.84) v1(26.45,72.69) v1(26.45,71.55) v1(26.83,73.33) v1(26.83,72.19) v1(43.21,79.93) v1(146.21,70.03) v1(146.84,70.03) v1(147.48,70.03) v1(148.11,70.03) v2(65.18,16.18) v2(65.18,15.42) v2(66.07,16.18) v2(66.07,15.42) v2(66.83,16.18) v2(66.83,15.42) v2(67.6,16.18) v2(67.6,15.42) v2(68.36,16.18) v2(68.36,15.42) v2(136.35,12.14) v2(136.35,11.4) v2(137.07,13.13) v2(137.07,12.37) v2(137.07,11.63) v2(137.83,13.13) v2(137.83,12.37) v2(137.83,11.63) v2(154.85,35.1) v2(155.61,35.86) v2(155.61,35.1) v2(155.63,34.36) v2(156.37,35.86) v2(156.37,35.1) v2(156.37,34.34) v2(157.13,35.1) v2(157.11,34.34) v2(177.32,72.57) v2(177.32,71.8) v2(177.32,71.04)
+VIN_BLIGHT:
  vias: v1(170.97,80.95) v1(171.23,78.79) v1(175.17,74.98)
+VIN_VCC_VCGI: length 25.4
  TOP w0.508: v2(52.23,79.55) 63.4,79.55 65.34,77.61 65.34,72.88 63.53,71.07 60.93,71.07 PR14.1
  vias: v1(49.18,79.68) v2(50.32,78.79) v2(51.21,78.79) v2(51.34,79.55) v2(52.1,78.79)
+VIN_VNN: length 8.7
  IN1 w0.508: v1(28.92,69.65) 28.92,71.49 29.49,72.05 v2(33.29,72.05)
  BOTTOM w0.508: v1(28.92,69.65) 28.92,68.69 29.37,68.25 PR168.1
  vias: v1(32.16,72.95) v2(33.35,72.85) v2(34.02,72.08) v2(34.09,72.82)
DVDD:
  vias: v1(159.04,41.83)
DVDD_IO: length 1.7
  TOP w0.254: v1(181.64,8.69) 180.49,9.84 R366.1
GND: length 933.6
  TOP w0.127: 34.73,64.67 34.73,64.62 ; PU4.11 PU4.15
  TOP w0.178: PU2.36 142.98,12.04 PU2.22
  TOP w0.203: U14.49 30.71,25.12 31.17,25.58 v1(31.5,25.58) ; U9.G8 136.2,57.51 135.8,57.91 v1(135.18,57.91) ; v1(22.23,38.89) 22.18,38.89 21.98,38.68 21.98,38.48 22.08,38.38 U14.1 ; U14.27 23.52,27.98 v1(23.91,28.37) ; v1(135.18,40.16) 135.21,40.13 135.85,40.13 136.25,39.73 U13.G8 ; C217.2 33.91,41.62 U14.104 33.91,39.19 33.43,38.71 33.43,38.7 v1(32.93,38.19) ; U14.91 v1(37.21,36.38)
  TOP w0.254: v1(95.03,15.8) 95.04,15.79 U17.16 ; Q16.1 v1(55.77,11.99) ; C323.2 97.05,7.54 v1(97.06,7.54) ; v1(93,7.54) 92.99,7.54 C322.2 ; v1(160.32,71.63) 160.18,71.48 160.18,71.1 R101.2 ; R28.2 115.59,87.67 v1(115.48,87.55) ; R44.1 113.76,79.62 113.37,80 113.37,80.18 113.24,80.31 113.24,80.32 112.94,80.63 v1(112.94,81.08) ; Q15.1 51.45,12.42 51.74,12.13 51.95,12.13 52.36,11.72 C314.1 ; v1(94.27,11.61) 94.01,11.86 U17.5 ; C42.1 C50.2 165.5,79.14 v1(164.7,78.34) ; v1(96.04,7.54) 96.04,7.54 R377.1 ; v1(31.66,83.87) 31.78,83.87 32.25,83.4 v1(32.25,81.96) 32.25,81.29 32.04,81.08 29.37,81.08 29.03,81.41 v1(29.03,83.02) 29.03,83.53 29.37,83.87 v1(29.88,83.87) ; C321.2 89.45,8.04 v1(89.95,7.54) ; U17.15 95.54,15.67 v1(95.66,15.8) ; v1(152.31,78.79) 152.31,78.92 152.56,79.17 D2.1 D1.1 ; C43.1 C51.2 167.28,78.54 v1(167.29,78.54) ; U17.12 97.94,13.76 v1(97.95,13.77) 97.95,14.15 97.84,14.26 U17.13 ; U17.10 v1(98.07,12.76) ; v1(55.38,10.49) 55.55,10.32 Q26.4 ; Q16.4 v1(57.07,16.54) ; Q7.1 158.71,74.18 v1(158.71,74.81) 158.59,74.93 Q5.1 ; v1(52.75,16.52) Q15.4
  TOP w0.279: v1(65.06,11.48) 65.06,10.95 64.94,10.83 Q23.4 ; U34.3 61.39,62.55 60.84,62 v1(60.76,62)
  TOP w0.305: U13.E3 v1(134.38,35.33) U13.D2 U13.E1 134.78,34.06 v1(135.18,33.66) 135.58,34.06 U13.F1 ; U13.K9 138.79,40.53 v1(139.21,40.95) ; v1(94.98,71.47) 94.32,70.81 94.32,70.29 R102.2 ; R90.1 96.66,75 v1(96.04,75.62) ; U13.K1 v1(139.18,34.53) ; v1(130.89,35.06) 131.03,34.93 U13.A2 U13.B2 ; U9.E3 134.75,53.51 v1(134.38,53.14) 133.98,52.74 U9.D2 133.98,52.68 v1(134.38,52.28) 134.75,51.91 U9.E1 134.78,51.47 v1(134.93,51.32) 135.53,51.91 U9.F1 v1(135.98,52.31) ; U13.N9 141.04,40.67 v1(141.04,41.06) ; U9.C9 133.18,58.95 v1(133.15,58.98) ; v1(142.23,51.36) 141.73,51.36 U9.N1 ; C210.2 135.66,44.76 136.44,43.98 C211.2 ; 99.61,63.25 v1(98.92,62.56) ; v1(96.76,71.47) 96.63,71.47 96.16,71.94 R96.2 ; v1(140.78,34.53) 141.18,34.13 U13.N1 ; v1(101.51,75.49) 101.51,75.85 C67.1 102.51,76.3 R84.1 R91.1 102.13,73.96 v1(102.13,73.61) ; U13.H9 137.07,40.64 137.07,41.26 137.15,41.34 v1(137.15,41.35) ; U13.D8 133.98,39.76 v1(134.38,40.16) 134.78,39.76 U13.E8 ; U9.N9 v1(141.18,58.93) ; v1(143.98,33.73) 143.98,33.77 143.62,34.13 U13.T1 ; U9.E8 v1(134.38,57.91) U9.D8 ; v1(137.58,33.73) U13.H1 ; v1(130.97,57.73) 131.19,57.51 U9.A8 ; v1(22,42.59) 21.75,42.85 U10.2 ; U9.K9 138.78,58.31 v1(139.18,57.91) ; U9.K1 138.78,51.75 138.83,51.69 v1(138.83,51.34) ; U9.T1 143.74,51.91 v1(144.09,51.56) ; v1(53.63,7.67) 53.63,7.19 53.83,6.98 54.13,6.98 54.25,7.1 Q26.1 ; v1(136.79,51.23) 137.18,51.62 U9.H1 ; v1(132.98,41.5) 133.18,41.3 U13.C9 ; v1(137.58,58.71) U9.H9 ; U9.B2 U9.A2 131.55,52.68 v1(130.99,52.68) ; U13.A8 131.55,39.7 v1(131.03,39.7) ; Q2.4 96.34,83.15 v1(96.17,82.98)
  TOP w0.381: v1(31.39,20.9) 31.4,20.91 C271.2 ; PQ4.1 165.94,65.12 v1(165.77,64.95) 164.46,64.95 PR35.2 ; R227.2 168.69,45.9 v1(167.93,46.66) ; v1(112.55,26.34) 113.01,26.8 C258.2 ; R110.2 75.28,67.23 v1(74.99,66.94) ; R98.2 104.6,71.89 104.3,72.19 v1(104.04,72.19) ; v1(52.61,58.98) 52.36,59.23 51.84,59.23 PR62.2 ; v1(108.24,60.83) 109.14,60.83 C138.1 ; C5.1 36.24,95.94 36.35,96.06 v1(37.02,96.06) ; PR82.2 158.87,29.26 156.46,29.26 PR83.2 ; v1(133.51,47.12) 133.51,47.61 C200.2 ; C58.2 116.11,78.59 116.43,78.27 116.43,78.03 116.69,77.77 v1(116.87,77.77) ; C251.2 77.76,27.49 77.45,27.18 77.45,26.64 77.81,26.29 v1(78.02,26.29) ; C23.2 v1(25.31,84.63) ; v1(21.24,34.47) 20.85,34.86 C231.2 ; v1(54.37,60.63) 54.37,60.89 PC45.1 ; C242.2 v1(139.48,29.26) ; v1(79.31,26.64) 79.31,27.83 C252.2 ; R151.1 v1(72.45,61.39) ; v1(76.32,26.63) 76.36,26.67 C250.2 ; D20.2 74.84,26.31 v1(75.08,26.07) ; C223.1 50.53,40.18 51.14,40.79 v1(51.14,41.22) ; v1(82.23,26.89) 82.71,27.37 R309.1 ; C192.2 148.52,49.58 v1(148.62,49.68) ; C222.1 148.55,40.74 v1(149.1,40.74) ; C279.2 50.2,21.66 49.74,22.12 v1(49.61,22.12) ; C68.1 80.36,75.68 80.73,75.31 81.26,75.31 v1(81.3,75.27) ; v1(95.26,77.7) 95.41,77.54 R70.2 ; v1(151.42,40.18) 151.95,40.71 C215.2 ; C205.1 90.9,44.83 v1(90.41,44.34) ; C281.2 104.05,20.65 103.81,20.88 103.81,21.59 104.29,22.07 v1(104.39,22.07) ; v1(118.52,95.55) U1.3 U1.8 ; C22.1 31.66,84.24 v1(31.66,83.87) ; R77.1 92.48,76.01 92.23,75.75 v1(92.22,75.75) 92.6,75.37 R88.2 ; v1(69.76,61.39) 69.76,61.39 R150.1 ; R361.1 v1(183.42,10.34) ; Y1.2 32.21,81.92 v1(32.25,81.96) ; v1(132.11,45.44) 131.6,44.93 R242.2 ; v1(159.17,41.06) C219.2 C220.1 ; R319.2 113.57,23.43 113.1,23.9 v1(113.06,23.9) 112.77,23.9 112.43,23.55 R318.2 ; R264.2 148.3,42.67 148.85,42.67 v1(148.87,42.64) ; R275.2 44.99,41.07 v1(45.24,40.82) ; v1(182.28,14.78) 182.67,14.38 R347.2 ; C39.1 113.56,78.54 v1(112.81,78.54) ; D19.2 89.06,27.23 89.06,26.21 89.48,25.79 v1(89.7,25.79) ; v1(19.29,19.73) C278.2 ; C189.1 148.07,50.65 v1(148.67,50.65) ; v1(108.95,43.12) 108.95,42.59 108.69,42.34 C216.1 ; v1(122.46,93.22) U2.8 U2.3 ; C226.2 41.84,37.01 v1(42.02,36.83) 42.02,36.57 41.43,35.99 C228.2 ; v1(134.25,47.1) 134.25,47.53 134.47,47.74 C201.1 ; C229.2 20.72,36.63 v1(21.24,36.12) ; C280.1 73.95,19.6 v1(73.95,18.79) ; v1(51.11,44.73) 51.09,44.75 C208.2 ; R25.2 25.93,87.63 25.33,87.04 v1(25.28,87.04) ; v1(80.93,26.19) 80.8,26.31 C253.2 ; v1(148.79,51.98) 149.91,51.98 R624.2 150.28,52.13 151.25,52.13 151.67,51.71 151.67,50.82 151.17,50.32 151.17,49.85 C193.2 C194.2 ; v1(174.02,11.48) 174.02,12.11 C305.2 ; C295.2 172.36,16.19 v1(171.86,16.69) 172.36,17.19 C288.2 ; C224.1 148.72,39.76 v1(149.14,39.76) ; C198.1 131.49,47.74 131.93,47.3 v1(131.93,47.08) ; C289.2 173.38,17.19 v1(172.88,16.69) 173.38,16.19 C296.2 ; C298.1 34.07,14.5 v1(33.86,14.7) ; 102.52,8.69 v1(102.52,7.54) ; R62.2 R53.1 92.1,80.57 v1(90.82,80.57) ; R131.1 74.95,63.55 74.75,63.75 v1(74.75,64.18) ; C149.2 95.99,58.74 v1(95.93,58.67) ; C316.1 v1(182.4,9.96) ; C212.1 107.35,43.98 107.35,45.17 C207.1 107.88,45.26 v1(108.81,46.19) ; v1(134.42,45.44) 134.14,45.16 C209.2 ; D12.2 82.2,39.57 v1(81.82,39.95) ; PC109.2 140.88,4.62 141.51,3.99 v1(141.61,3.99) 142.28,4.66 PC110.1 ; Y1.4 v1(29.03,83.02) ; v1(152.73,47.34) 152.23,47.34 C202.2 ; R97.2 107.48,72.31 v1(107.43,72.36) ; v1(110.4,81.84) 110.98,82.42 PQ1.1 ; PR46.2 47.65,63.03 48.29,63.68 v1(48.42,63.68) ; D30.1 v1(174.78,7.42) ; C184.1 C186.1 64.94,49.88 v1(65.14,49.67) ; v1(98.93,26.91) 98.71,27.13 C249.2 ; L8.1 v1(46.9,26.34) ; v1(39.15,64.06) PC42.2 PC43.2 ; v1(142.78,75.11) 143.41,74.48 PC19.2 PC21.2 ; PR126.2 143.67,4.47 v1(143.16,3.96) ; R74.2 98.75,78.25 98.83,78.25 99.08,78 99.08,77.99 99.25,77.81 99.25,77.8 99.36,77.7 99.42,77.7 99.67,77.45 R73.1 99.73,76.62 R633.1 99.73,76.38 v1(99.73,75.61) ; R139.1 72.16,62.41 v1(71.66,62.91) 71.66,62.91 R138.1 ; C320.2 174.99,10.64 v1(174.78,10.84) ; C21.1 v1(29.88,83.87) ; R118.1 81.67,66.09 v1(81.74,66.01) ; C150.1 99.6,58.7 v1(99.63,58.67) ; v1(67.6,62.53) 67.6,63.17 67.34,63.42 R133.1 ; v1(135.16,45.44) 135.41,45.18 C210.2 ; v1(96.09,43.64) 96.27,43.81 C206.2 ; v1(140.62,29.23) 140.75,29.36 C243.1 R299.2 ; v1(48.8,61.61) 49.02,61.39 PR52.2 ; v1(151.33,40.94) 150.81,41.46 C214.2 ; C260.2 v1(116.03,27.23) ; R316.2 176.82,25.32 v1(176.44,24.94) ; v1(149.77,11.86) 149.76,11.85 C317.2 ; v1(26.77,67.81) 27.33,67.25 PR27.2 ; R163.2 63.03,59.67 64.55,61.19 v1(64.55,62.91) ; v1(146.97,3.99) 147.47,4.49 PC111.1 ; v1(82.18,90.83) 82.18,91.39 81.95,91.62 81.95,91.73 EC4.1 ; v1(54.44,25.8) 54.87,25.8 55.43,26.36 C255.2 ; R283.2 v1(167.93,36.88) ; D13.2 83.1,39.83 83.1,40.62 83.5,41.02 v1(83.67,41.02) ; C236.2 20.94,32.05 v1(21.37,32.48) ; C199.2 132.56,47.55 v1(132.56,47.09) ; C274.2 61.37,21.95 60.7,22.63 v1(60.63,22.63) ; PR42.2 v1(28.73,64.18) 28.11,64.8 PC41.2 ; v1(70.8,95.91) 70.51,95.62 EC2.1 ; C196.1 136.69,48.41 136.08,47.8 135.8,47.8 135.08,47.08 v1(134.93,47.08) ; C282.2 v1(94.77,18.72) ; C24.2 v1(27.84,84) ; D23.2 v1(76.36,18.72) ; C245.2 v1(19.21,29.01) ; C244.2 143.16,29.53 v1(142.89,29.26) ; C241.2 v1(138.08,29.26) ; Q4.1 162.84,77.02 R67.1 162.84,78.27 v1(163.35,78.79) ; v1(88.4,51.36) 88.69,51.07 C191.1 ; v1(93.83,75.87) 93.76,75.8 C80.2 ; v1(128.63,52.39) 128.13,52.89 R193.2 ; v1(109.25,26.95) C254.2 ; U12.2 47.15,44.47 47.03,44.59 v1(47.03,44.84) ; C311.2 179.32,11.7 v1(178.85,11.23) 178.37,11.7 C310.1 ; C81.2 v1(101.51,75.49) ; C237.2 v1(116.03,30.28) ; v1(93.25,84) 93.25,84.5 93.65,84.9 Q2.1 ; v1(62.03,49.68) v1(62.68,49.68) ; v1(50.92,69.53) 50.92,69.34 PC32.2 ; v1(133.38,45.46) 132.87,44.96 R243.2 ; v1(92.22,87.17) 92.74,87.69 C16.2 ; PC47.2 v1(29.24,60.31) ; v1(131.29,47.09) 131.29,46.88 131.87,46.31 C197.1 ; R192.1 R191.1 67.48,52.2 v1(67.39,52.12) ; v1(98.67,56.54) 98.22,56.54 R175.2 98.03,57.11 R170.2 ; v1(114.33,54.66) 114.33,55.05 R177.2 ; R297.1 v1(42.07,30.91)
  TOP w0.406: CP2.2 24.59,12.04 v1(24.29,11.73) 23.81,12.22 CP2.4 ; CP3.8 26.4,11.97 v1(26.64,11.73) 27.18,12.28 CP3.6 ; CP4.6 31.25,12.22 v1(30.77,11.73) 30.46,12.04 CP4.8 ; CP5.6 37.34,12.09 v1(36.96,11.71) 36.56,12.11 CP5.8 ; CP3.4 28,12.25 v1(28.49,11.76) 28.78,12.05 CP3.2 ; CP1.8 18.14,12.02 v1(18.41,11.76) 18.93,12.28 CP1.6 ; CP2.8 22.21,11.97 v1(22.44,11.73) 22.99,12.28 CP2.6 ; CP1.4 19.74,12.28 v1(20.27,11.76) 20.53,12.02 CP1.2 ; CP5.2 38.94,12.09 v1(38.56,11.71) 38.16,12.11 CP5.4 ; CP6.6 41.54,11.77 v1(40.99,11.23) 40.75,11.46 CP6.8 ; CP4.4 32.06,11.97 v1(32.3,11.73) 32.85,12.28 CP4.2 ; CP6.4 42.35,11.71 v1(42.83,11.23) 43.14,11.53 CP6.2
  TOP w0.508: PR82.2 159.64,30.87 159.67,30.91 PQ11.1 159.67,33.82 PC60.2 ; v1(15.93,21.84) 15.93,20.78 D24.2 ; R385.2 157.01,5.52 v1(156.75,5.26) ; C151.2 118.9,58.25 v1(118.9,57.88) ; C328.2 167.42,4.74 v1(168.17,4.74) ; C103.2 100.89,68.37 v1(100.45,68.37) ; C152.1 110.47,58.71 v1(110.47,58.14) ; C76.1 153.19,75.11 v1(153.45,74.85) ; 64.72,55 65.06,55.35 C173.1 C164.2 65.24,57.38 v1(66.03,57.38) ; 64.72,55 64.29,55.42 63.54,55.42 v1(63.37,55.24) ; 64.72,55 R183.2 ; C326.2 164.5,5.76 v1(164.5,6.53) ; PQ8.1 156.8,52.45 v1(156.62,52.63) ; v1(151.14,9.5) 151.14,9.41 PC100.1 ; C294.2 186.73,17.03 v1(186.6,17.17) ; R315.1 175.68,25.2 v1(175.29,25.2) ; C302.2 181.27,13.25 v1(181.77,12.75) 181.27,12.25 C309.2 ; C140.2 106.85,60.87 v1(106.84,60.88) ; v1(17.18,33.32) 17.55,33.32 C233.1 ; v1(174.3,69.92) 173.98,70.24 PR20.2 ; C163.2 62.04,57.21 C162.1 62.01,57.25 v1(61.53,57.73) 61,57.2 C161.2 ; R205.1 43.22,49.95 v1(43.21,49.96) ; C221.2 v1(22,40.94) ; v1(167.8,28.12) 168.31,28.62 C246.1 ; v1(80.17,16.31) 79.84,15.97 Q18.1 ; v1(150.53,6.09) 150.53,6.77 PC106.1 PR113.2 ; v1(59.39,60.63) 59.21,60.44 C542.2 ; PC92.2 v1(154.59,12.37) ; v1(87.46,26.54) 87.54,26.62 C256.2 ; HE1.3 184.06,12.75 v1(184.06,11.99) ; D7.2 168.69,50.26 v1(168.69,49.38) ; PC87.2 138.75,13.22 v1(139.35,12.62) ; R48.2 126.02,81.32 v1(126.02,82.22) 125.52,82.22 R45.2 ; 70.53,86.56 70.53,89.69 70.51,89.71 EC3.1 ; C292.2 v1(114.08,16.43) ; PQ7.1 158.15,56.23 v1(157.77,55.85) ; PC56.2 156.84,48.47 158.15,47.17 ; v1(66.45,8.94) 66.95,8.44 C324.2 ; v1(108.26,55.49) 108.61,55.84 C166.1 ; C156.2 61.41,58.62 v1(61.88,58.62) ; D15.2 v1(167.9,38.23) ; R346.2 v1(174.78,14.4) ; C1.2 v1(46.9,102.23) ; v1(85.82,18.74) 85.82,19.5 D25.2 ; C262.2 116.69,26.7 v1(116.69,27.25) ; PC48.2 38.38,61 v1(37.88,60.5) ; v1(60.36,65.07) 60.36,64.7 R461.2 ; C93.1 96.75,69.33 v1(96.76,69.34) ; C275.2 115.35,21.74 v1(115.32,21.77) ; C170.2 167.05,55.41 v1(167.29,55.17) ; C15.1 103.12,91.33 v1(103.16,91.36) ; v1(30.74,70.51) 30.63,70.4 PC28.1 PC33.2 ; PR123.1 v1(145.7,5.89) ; PC99.2 138.75,8.97 v1(139.35,9.57) ; v1(176.44,24.94) 176.94,24.43 C268.2 ; C4.1 29.29,95.7 v1(29.29,94.99) ; C187.2 84.59,51.1 v1(85.68,52.19) ; C290.2 v1(112.05,16.43) ; C7.1 112.47,94.67 v1(111.92,95.22) ; R159.1 R167.1 74.62,59.1 v1(74.45,58.94) ; C137.2 104.69,61.77 v1(104.68,61.78) ; C273.2 v1(116.62,22.27) ; C325.2 124.5,6.62 124,6.12 v1(123.45,6.12) ; C74.2 152.05,75.23 v1(153.07,74.22) ; PQ5.1 159.8,61.47 159.24,62.03 v1(158.78,62.03) ; v2(47.78,66.22) 48.47,66.22 48.72,66.47 PC37.2 ; C204.2 134.4,46.06 134.4,45.46 v1(134.42,45.44) ; v1(155.35,5) 155.35,5.37 PC107.2 ; C327.2 165.64,4.74 v1(166.15,4.74) ; v1(109,86.52) 109,86.32 C20.1 ; C267.2 175.26,24.02 v1(174.66,23.42) ; v1(29.95,95.05) 30.12,94.88 C6.2 ; PC93.2 v1(155.61,12.37) ; D28.1 C312.2 v1(170.21,11.99) ; C306.2 174.78,12.11 v1(175.17,11.73) ; v1(77.88,18.79) 77.79,18.88 C285.2 ; v1(147.81,57.2) 147.35,57.66 C157.2 ; Q19.1 83.6,15.8 v1(83.09,16.31) ; PC23.1 57.08,70.9 v1(57.8,70.9) ; v1(50.68,59.87) 50.2,59.87 49.82,60.25 C147.1 ; C299.1 35.17,13.16 v1(35.17,12.57) ; HOLE6.1 HOLE6.4 ; v1(141.76,16.56) 141.65,16.56 141.36,16.85 141.36,17.04 PC76.1 ; PR101.2 v1(149.13,12.88) ; PC65.2 167.58,29.93 v1(167.93,30.28) ; v1(19.39,26.82) 19.74,26.47 R314.2 ; C293.2 v1(115.09,16.43) ; C300.2 v1(66.96,14.65) ; PC20.2 60.36,73.71 60.61,73.96 v2(61.37,73.96) ; C234.2 v1(170.85,33.83) ; v1(65.06,11.48) 65.05,11.47 C313.2 ; C225.1 163.21,38.9 163.58,38.53 163.86,38.53 165.13,37.26 v1(165.77,37.26) ; R248.2 v1(23.78,45.39) ; R66.1 C58.2 ; PQ9.1 v1(113.57,38.28) 112.12,38.28 v1(111.66,37.82) ; 106.33,8.69 v1(106.33,7.54) ; v1(53.62,10.49) 53.47,10.64 C319.1 ; v1(118.65,8.56) 118.47,8.38 Q27.1 ; PC94.2 v1(156.62,12.37) ; v1(66.22,25.57) 65.85,25.57 64.96,26.46 C259.2 ; C301.2 v1(67.98,14.65) ; v1(53.6,11.99) 53.22,11.61 C314.1 ; PC81.2 113.06,15.96 v1(113.06,16.43) C291.2 ; J1.2 v1(69.5,11.48) ; v1(154.72,47.93) 154.98,47.93 155.49,47.42 156.95,47.42 157.52,46.85 PR74.1 ; U15.2 171.08,31.04 170.59,31.52 v1(170.59,31.55) ; PR90.2 v1(147.99,16.56) ; C277.2 96.04,19.61 v1(96.93,18.72) ; R47.1 R44.1 ; C329.2 169.2,4.74 v1(169.83,4.74) ; PC78.1 145.58,17.08 v1(146.1,16.56) ; C111.1 94.5,66.08 v1(95.12,65.46) ; R334.2 v1(93.76,18.72) ; v1(17.18,31.04) 17.19,31.05 R295.1 ; PR115.2 110.27,5.76 ; PC74.2 136.68,17.96 v2(136.81,18.08) ; v1(155.99,5) 156.12,5.13 PC108.2 ; C240.2 v1(136.94,29.26) ; v1(103.04,56.53) 102.22,56.53 C167.1 ; PR88.2 PC82.1 140.11,16 v1(140.67,16.56) ; HOLE8.4 HOLE8.1 ; C276.2 v1(82.84,18.77) ; C283.1 v1(167.8,19.99) ; R249.1 v1(29.23,44.62)
  IN3 w0.254: 171.48,18.49 v1(171.48,19.35) 171.36,19.48 v1(171.36,25.03) 171.36,25.46 170.59,26.22 v1(170.59,31.55) 170.59,33.58 v1(170.85,33.83) 168.76,35.91 168.76,42.77 v1(168.56,42.98) 168.56,43.06 168.14,43.48 167.72,43.48 167.42,43.19 167.42,41.71 167.9,41.22 v1(167.9,38.23) 167.93,38.2 v1(167.93,36.88) 167.93,35.77 169.69,34 169.69,26.22 169.96,25.96 v1(169.96,23.33) 170.59,22.69 170.59,19.43 169.15,17.98 169.15,17.32 170.06,16.41
  BOTTOM w0.079: U22.AR54 86.44,59.44 86.67,59.44 86.73,59.38
  BOTTOM w0.086: v1(65.14,49.67) 64.96,49.67 64.64,49.99 64.64,50.49 ; 65.14,50.49 65.14,50.06
  BOTTOM w0.089: 64.64,50.49 U26.N2 65.14,50.49 ; U22.AU53 86.9,59.22 86.8,59.32 86.79,59.32 86.73,59.38 ; v1(108.24,60.83) 108.57,60.5 U22.AN3 ; U22.AF53 U22.AF55 ; U22.AN53 86.47,60.69 86.39,60.75 U22.AM55 ; U22.AR2 108.87,59.41 108.76,59.33 108.66,59.22 U22.AU3 108.66,58.23 108.34,57.91 108.34,57.57 v1(108.24,57.46) ; 65.14,50.06 v1(65.14,49.67)
  BOTTOM w0.127: v1(84.23,61.64) 84.52,61.93 85.88,61.93 U22.AK55
  BOTTOM w0.152: U22.L8 U22.L7
  BOTTOM w0.178: U26.P4 U26.N5 U26.P6 ; v1(63.37,55.24) 63.4,55.24 U26.C4
  BOTTOM w0.191: U22.BL8 106.85,52.21 106.83,52.18 107.08,51.66 107.1,51.65 v1(107.11,51.63)
  BOTTOM w0.202: U22.BC11 v1(105.86,55.75) U22.BD9
  BOTTOM w0.203: U22.BL32 95.98,51.29 v1(96.02,51.25) ; U22.BK55 86.08,52.89 U22.BJ54 ; U22.AK1 109.52,61.77 109.05,61.77 U22.AK3 ; v1(88.77,72.89) 88.79,72.92 88.79,73.37 89.03,73.61 89.79,73.61 90.13,73.27 U22.D45 ; U22.B2 109.59,74.21 U22.C1 ; U22.AY15 103.57,57.61 v1(103.95,57.23) 104.33,57.61 U22.AY13 ; U22.AR7 107.17,59.7 v1(107.55,59.33) ; PU14.8 165.04,31.84 165.32,32.12 165.82,32.12 v1(165.87,32.17) ; U22.AW5 107.88,57.82 v1(108.24,57.46) ; PU13.8 155.21,45.86 154.73,45.38 v1(154.72,45.38) ; U22.BH45 90.17,54.05 v1(90.62,53.61) ; v1(96.63,66.91) 96.27,66.55 U22.Y31 ; PU15.1 145.61,23.38 v1(145.32,23.67) ; U26.H10 60.61,53.24 v1(60.44,53.41) ; v1(145.32,24.69) 145.21,24.79 PU15.14 ; v1(97.4,64.74) 97.04,65.1 U22.AC29 ; U22.AW10 105.49,57.66 105.49,57.51 v1(105.44,57.45) ; v1(106.85,68.97) 106.46,68.58 U22.R8 ; v1(107.43,72.36) 106.46,71.39 U22.J8 ; U22.AR12 U22.AR10 ; U26.E7 62.39,53.75 62.52,53.62 v1(62.91,53.62) 63.03,53.74 U26.G5 ; U22.C36 94.05,74.46 94.05,74.85 U22.A36 94.01,75.13 94.01,75.49 93.83,75.67 v1(93.83,75.87) ; U22.BG1 109.74,54 109.82,54 110,53.83 110.06,53.76 v1(110.06,53.59) ; U22.F4 v1(108.47,73.36)
  BOTTOM w0.229: U22.AK3 U22.AL3 ; U22.BL42 91.35,52.22 91.35,51.28 v1(91.14,51.08) ; v1(94.69,51.57) 94.69,52.48 U22.BK35 ; v1(90.71,75.71) 90.71,75.53 90.57,75.38 U22.A44 ; U22.V55 85.68,67.26 v1(85.48,67.46) ; U22.AF55 85.71,63.63 85.15,63.63 v1(85.1,63.68) ; v1(102.96,59.16) 102.57,58.77 U22.AV17 ; v1(102.96,59.16) 102.86,59.26 102.86,59.69 U22.AR17 ; v1(102.96,59.16) 103.25,58.87 103.25,58.52 U22.AV15 ; v1(88.81,75.74) 88.76,75.69 U22.A48 ; U22.BH31 v1(95.93,53.7) U22.BJ31 ; U22.AW2 109.38,57.69 109.87,57.69 110.32,58.14 v1(110.47,58.14) ; U22.BB28 U22.BA27 ; U22.BB28 U22.BA29 ; U22.BB28 U22.AY28 U22.AW28 U22.AU28 ; U22.BB28 U22.BD28 U22.BE28 U22.BG28 U22.BH28 U22.BJ28 U22.BL28 v1(97.78,50.94) ; U22.BL24 99.61,52.31 99.61,51.9 v1(99.47,51.57) ; U22.BC31 96.17,56.01 96.1,55.94 95.77,55.94 U22.BC33 ; U22.BL5 107.97,52.17 108.3,51.83 v1(108.3,51.58) ; v1(109.86,52.33) 109.86,52.52 U22.BK1 109.15,52.78 U22.BJ2 ; U22.BC5 v1(108.26,55.49) 108.65,55.09 U22.BE3 ; U22.BL48 88.74,52.31 88.74,52.11 88.49,51.87 88.49,51.47 88.4,51.38 v1(88.4,51.36) ; U22.A16 103.13,74.91 103.13,74.4 U22.C16 103.19,73.82 ; U22.AA35 94.76,65.82 v1(95.12,65.46) ; U22.AM55 85.28,60.95 v1(85.25,60.98) ; v1(92.22,75.75) 92.22,75.63 92.37,75.48 U22.A40 ; U22.BG6 v1(106.85,54.32) U22.BF9 ; U22.A51 87.59,75.68 v1(87.54,75.74) ; U22.BL14 104.09,51.35 104.08,51.33 v1(104.08,51.31) ; U22.BK39 92.89,52.48 v1(92.89,51.76) ; U22.BL10 105.9,51.73 v1(105.94,51.69) ; U22.A32 96,75.24 96,75.33 96.01,75.34 v1(96.04,75.62) ; U22.BD15 v1(104,55.12) ; v1(85.26,53.39) 85.25,53.39 85.86,54 U22.BG55 ; v1(87.13,51.52) 87.13,51.6 87.59,52.07 U22.BL51 ; v1(85.68,52.19) 85.68,52.49 U22.BK55 ; U22.BC25 99.55,55.9 v1(99.63,55.83) 99.65,55.83 U22.BC23 ; U22.BB55 85.2,56.44 84.92,56.15 v1(84.6,56.15) ; v1(85.32,65.58) 85.84,65.58 U22.AB55 ; v1(100.83,51.57) 100.83,52.54 U22.BK21 ; U22.AF3 U22.AF4 U22.AF6 ; U22.K3 109.06,70.95 109.51,70.95 U22.K1 ; U22.E55 v1(84.78,73.31) ; U22.D55 85.63,73.92 85.37,74.18 v1(84.82,74.18) ; U22.BB1 110.46,56.44 v1(110.65,56.25) ; v1(84.77,57.64) 85.24,57.64 85.29,57.68 86.17,57.68 U22.AW54 ; U22.BC17 v1(103.04,56.53) ; U22.BK17 102.64,52.56 102.64,51.81 v1(102.7,51.76) ; U22.BC39 92.69,56.4 92.33,56.4 92.29,56.37 92.11,56.23 U22.BC41 v1(91.55,55.83) ; v1(85.53,69.2) 85.73,69.2 85.87,69.06 U22.P55 ; U22.A20 101.39,75.37 v1(101.51,75.49) ; U22.AR54 86.18,59.5 85.53,59.5 85.53,59.5 85.08,59.5 v1(85.07,59.51) ; U22.BL46 89.66,51.6 v1(89.54,51.47) ; U22.BH11 104.97,53.71 104.97,53.71 v1(104.95,53.7) 104.93,53.7 104.88,53.74 U22.BH13
  BOTTOM w0.25: U22.BA29 96.89,56.54 U22.BC31 ; v1(107.62,75.49) U22.A6
  BOTTOM w0.254: v1(109.2,75.79) 109.2,75.36 U22.A3 ; U22.BJ41 91.92,53.33 v1(91.6,53.64) 92.01,54.05 U22.BH41 ; v1(99.73,75.61) 99.73,75.11 U22.A24 ; v1(90.62,71.31) 90.42,71.12 U22.J45 ; U22.AW51 87.68,57.79 v1(87.33,57.43) ; CN5.17 163.48,80.95 v1(163.48,80.95) ; PC209.1 153.31,40.43 v1(152.81,39.93) ; v1(87.91,71.8) 87.91,71.53 U22.J51 ; v1(104.76,18.67) 104.53,18.9 JDIM1.222 ; v1(84.75,75.13) 84.89,74.98 85.51,74.98 U22.B55 ; U22.BH33 95.58,54.05 v1(95.93,53.7) ; v1(46.9,26.34) 47.27,26.72 JDIM1.1 ; v1(170.34,78.54) 170.52,78.54 171.24,77.81 C375.1 ; U22.AF1 110.24,63.65 v1(110.27,63.68) ; U22.D9 106.3,73.35 106.83,73.88 U22.D6 ; v1(92.49,69.39) 92.35,69.39 U22.M41 91.73,69.39 v1(91.63,69.39) ; U22.BC25 98.69,56.53 v1(98.67,56.54) U22.BA27 ; v1(99.63,53.72) 99.96,54.05 U22.BH23 ; v1(99.63,53.72) 99.53,53.72 99.2,54.05 U22.BH25 ; v1(99.63,53.72) 99.18,53.27 U22.BJ25 ; v1(161.96,80.95) 161.98,80.92 CN5.20 ; U22.AR10 U22.AN10 ; U22.BD37 U22.BF37 U22.BH37 ; U22.BD37 U22.BC37 U22.BC39 ; U22.BD37 U22.BD35 94.49,55.53 94.49,56.13 U22.BC35 94.82,56.45 95.16,56.45 U22.BC33 ; v1(92.5,73.04) 92.29,73.25 U22.D41 ; U22.BC21 100.86,56.34 100.28,56.34 U22.BC23 ; v1(110.01,71.39) 110.01,71.28 U22.K1 ; v1(31.39,20.9) 30.9,20.41 CN10.39 ; v1(42.25,18.23) 42.2,18.18 U33.2 ; v1(85.35,71.16) 85.64,70.87 U22.K55 ; U22.BH37 93.87,53.42 U22.BJ37 ; U22.BH37 U22.BH39 92.77,54.05 v1(92.4,53.68) ; v1(25.53,25.77) 25.53,25.78 25.65,25.9 CN10.18 ; 170.47,16.66 v1(170.47,17.83) ; v1(108.24,69.87) 108.24,70.03 107.92,70.35 U22.L5 ; v1(88.77,72.89) 88.41,73.25 U22.E50 ; v1(110.24,61.12) 109.85,61.12 109.67,60.95 U22.AM1 ; v1(163.81,70) 163.35,70.46 R473.1 ; U22.M15 103.16,70.05 v1(103.01,70.05) ; D38.1 v1(155.35,74.85) ; U25.E3 134.78,56.44 134.12,55.78 134.12,55.78 133.76,55.42 v1(133.64,55.29) ; v1(62.68,49.68) 62.89,49.89 U26.P6 ; v1(61.13,51.76) 61.51,51.76 61.89,52.14 U26.K8 ; U22.BE53 v1(87.32,55.52) U22.BC51 ; D37.1 v1(154.08,74.85) ; CN15.7 53.85,7.44 v1(53.63,7.67) ; U22.N12 105.44,68.99 v1(106.1,68.99) ; U22.H13 104.47,71.87 104.16,72.19 v1(104.04,72.19) 103.91,72.19 103.56,71.83 U22.H15 ; 107.6,61.77 108.29,61.77 U22.AL3 ; v1(107.53,69.87) 107.53,69.99 U22.L7 ; CN15.4 55.35,10.45 v1(55.38,10.49) ; R507.2 115.3,60.37 v1(115.3,59.97) ; PU6.19 143.93,80.68 v1(143.8,80.82) ; U32.22 130.95,24.18 U32.3 ; v1(87.37,69.87) 87.68,69.46 U22.N51 ; U22.W51 U22.W49 ; U32.13 128.95,24.18 U32.24 ; v1(160.43,78.79) 160.48,78.84 CN5.23 ; PC206.1 154.8,43.87 v1(154.72,43.8)
  BOTTOM w0.305: U9.A2 131.55,52.68 v1(130.99,52.68) ; v1(143.98,58.71) 143.58,58.31 U25.T1 ; v1(44.23,57.63) 44.23,57.9 43.79,58.34 U23.2 ; C419.2 151.2,47.75 151.31,47.75 151.91,47.16 C202.2 ; U30.B2 U13.A8 131.55,39.7 v1(131.03,39.7) ; CN7.12 45.99,52.72 v1(45.52,53.19) ; v1(140.78,34.53) 141.18,34.13 U13.N1 ; v1(137.15,41.35) 137.15,41.34 137.07,41.26 137.07,40.64 U13.H9 ; U13.A2 131.03,34.93 v1(130.89,35.06) ; U25.B2 U9.A8 131.19,57.51 v1(130.97,57.73) ; v1(36.72,18.38) 36.72,18.54 36.9,18.72 CN10.63 ; U30.F1 135.46,40.53 135.18,40.25 v1(135.18,40.16) ; U30.G8 U13.H1 v1(137.58,33.73) ; v1(135.98,52.31) U25.G8 ; CN7.10 47.69,53.72 v1(47.81,53.85) ; U25.E1 v1(134.38,57.91) U9.D8 ; v1(141.04,41.06) 141.04,40.67 U13.N9 ; CN10.45 v1(32.4,18.41) ; v1(139.18,57.91) 138.78,58.31 U9.K9 ; U22.D9 105.95,73.61 v1(105.86,73.61) ; U9.H1 137.18,51.78 136.79,51.38 v1(136.79,51.23) ; CN10.69 38.4,18.77 37.99,18.36 v1(37.36,18.36) ; CN7.8 45.88,54.72 v1(45.68,54.53) ; U30.E3 134.78,38.84 v1(134.37,38.42) ; U13.K1 v1(139.18,34.53) ; U30.T1 143.58,40.75 v1(143.21,41.12) ; Q35.1 18.44,21.12 v1(18.78,21.46) ; v1(139.21,40.95) 138.79,40.53 U13.K9 ; U9.D2 133.98,52.74 v1(134.38,53.14) 134.78,52.74 U25.E8 ; v1(29.67,20.9) 29.4,20.63 CN10.33 ; U22.J41 92.39,71.47 92.46,71.47 92.46,71.48 v1(92.47,71.48) 92.64,71.48 U22.H39 ; CN7.14 47.67,51.72 v1(47.86,51.54) ; U22.C12 U22.A12 105.39,75.36 v1(105.39,75.49) ; v1(133.03,51.34) 133.14,51.46 133.14,51.87 U25.C9 ; v1(137.58,58.71) U9.H9 ; U13.D8 133.98,39.76 v1(134.38,40.16) 134.75,40.53 U30.E1 ; v1(22.9,18.34) CN10.7 ; v1(89.44,69.87) 89.44,69.76 U22.N46 ; CN10.1 v1(21.4,18.34) ; U13.D2 v1(134.38,35.33) U30.E8 ; CN10.51 33.9,20.44 v1(34.36,20.91) ; U9.N9 v1(141.18,58.93) ; v1(15.91,18.85) 15.91,19.5 Q35.4 ; v1(135.18,57.91) U25.F1 ; U9.K1 138.78,51.75 138.83,51.69 v1(138.83,51.34) ; v1(95.03,70.03) 94.88,70.03 U22.M35 ; v1(133.18,33.59) U30.C9 ; CN10.57 v1(35.4,20.78)
  BOTTOM w0.33: v1(100.79,78.54) 100.8,78.54 101.32,79.05 R443.1
  BOTTOM w0.381: C230.1 v1(148.88,34.59) ; R543.2 38.14,44.06 v1(37.88,43.8) ; PR250.2 139.5,22.91 v1(139.48,22.93) ; C401.2 138.72,63.05 v1(138.72,63.3) ; v1(134.75,63.3) 134.75,62.95 R144.2 ; C431.2 148.67,39.29 v1(149.14,39.76) ; R502.1 71.91,62.66 v1(71.66,62.91) ; v1(114.64,70.76) 114.69,70.76 115.22,70.23 C390.1 ; C430.2 125.63,37.9 v1(125.63,37.65) ; v1(110.14,74.85) 110.14,74.73 U22.C1 ; v1(115.35,66.34) 115.75,65.94 117.84,65.94 118.35,66.45 Y3.4 118.89,67.17 v1(119.41,67.69) v1(119.41,68.63) v1(119.41,69.44) 119.41,70.15 119.11,70.45 116.85,70.45 116.65,70.25 Y3.2 ; PC186.2 160.42,63.12 PR195.2 ; v1(48.8,61.61) 49.01,61.61 PC188.2 ; v1(19.21,29.01) 19.33,29.12 C447.1 ; v1(122.82,71.78) 122.51,72.08 PC147.2 ; v1(134.12,63.3) 134.12,62.9 C127.2 ; R429.1 v1(106.84,81.84) ; R415.1 104.34,83.71 v1(104.31,83.71) 104.26,83.71 C353.1 ; v1(72.42,64.18) 72.42,64.81 R488.1 ; v1(167.93,33.32) 167.43,32.82 PR236.1 ; PC219.2 167.43,28.49 v1(167.8,28.12) 168.43,28.74 C448.2 ; C243.1 140.75,29.36 v1(140.62,29.23) ; R533.2 v1(148.67,50.65) ; v1(169.58,63.17) 169.2,63.55 R493.1 ; U27.2 54.11,55.98 v1(53.52,56.56) ; v1(137.81,63.16) 137.76,63.16 137.73,63.19 137.71,63.19 137.19,62.67 C400.1 ; PC215.1 165.33,33.39 v1(165.89,33.39) ; v1(165.89,34.02) 165.71,34.02 PR234.1 ; v1(152.73,47.34) 153.06,47.67 PC201.2 ; PC160.2 62.78,67.68 v1(62.87,67.59) 62.52,67.23 PR177.2 ; v1(15.86,18.13) 15.86,17.91 C471.1 ; C419.2 150.4,48.55 150.4,49.33 150.85,49.78 150.97,49.78 C193.2 ; PC203.2 153.31,45.52 v1(152.81,46.02) 153.31,46.52 PC202.1 ; C443.1 v1(30.64,28.75) ; C432.2 126.9,38.15 v1(126.9,37.65) ; R575.2 126.02,20.11 v1(126.02,19.61) ; C421.2 40.65,46.19 v1(40.65,45.65) ; v1(44.1,46.91) 44.23,46.91 44.5,47.18 C417.2 ; U9.N1 141.73,51.36 v1(142.23,51.36) ; PC223.2 v1(139.48,23.93) ; C376.1 163.35,77.65 v1(163.35,78.79) ; C362.1 101.77,80.96 v1(101.45,80.64) ; C444.1 33.63,29.89 v1(33.41,29.66) ; v1(128.63,52.39) 128.63,52.51 128.12,53.02 R531.2 ; PC193.2 20.44,59.93 v1(20.5,59.87) ; C423.1 148.17,42.64 v1(148.87,42.64) ; v1(54.14,59.74) 54.14,59.76 54.16,59.74 PC194.1 ; v1(167.8,25.7) 167.81,25.69 168.42,25.69 C452.2 ; PC221.2 v1(139.48,24.94) ; R430.1 107.86,81.33 v1(108.36,81.84) ; v1(69.76,61.39) 69.76,61.39 R150.1 ; v1(151.33,40.94) 150.4,41.87 C424.2 ; U22.AR10 U22.AU10 ; v1(78.9,90.73) 78.9,91.36 79.15,91.62 ESD2.2 ; C427.2 148.8,40.44 v1(149.1,40.74) 148.65,41.2 148.5,41.2 C425.2 ; v1(48.8,18.44) 48.83,18.46 49.59,17.7 C484.2 ; v1(67.91,57.96) R520.2 ; PC205.1 153.31,43.47 v1(152.81,42.98) 153.31,42.48 PR230.1 ; v1(39.15,67.99) 39.27,67.99 PC165.2 ; v1(147.81,57.2) 147.35,57.66 C157.2 ; C402.1 139.61,62.92 v1(139.61,63.3) ; R477.1 82.73,69.52 v1(83.17,69.95) ; v1(21.24,34.47) 20.72,33.95 C434.1 ; C361.1 99.21,80.96 v1(99.48,80.69) ; C241.2 v1(138.08,29.26) ; v1(136.67,63.16) 136.66,63.16 R145.2 ; C202.2 152.09,47.16 152.56,46.68 v1(152.61,46.68) ; v1(105.95,81.84) 105.95,81.71 105.82,81.58 R428.1 ; v1(48.42,63.68) 48.66,63.68 PC181.2 ; C438.2 168.43,30.79 v1(167.93,31.29) ; v1(175.67,72.82) 175.67,73.45 C388.2 176.31,73.32 v1(176.31,72.82) ; v1(110.1,73.6) 110.1,73.46 109.63,72.99 U22.F1 ; C351.2 92.62,83.75 v1(92.62,84) ; C426.1 38.65,41.27 38.8,41.42 v1(38.8,41.81) ; R508.2 68.86,59.99 67.88,59.99 67.53,59.65 67.53,59.17 67.94,58.76 v1(68.1,58.76) ; v1(142.89,29.26) 143.16,29.53 C244.2 ; C413.1 148,52.77 v1(148.79,51.98) 148.6,51.79 C414.2 ; R151.1 v1(72.45,61.39) ; PR242.1 v1(146.34,28.5) ; v1(104.02,87.15) 104.43,87.56 R399.2 ; PC182.2 60.23,64.32 60.23,64.95 v1(60.36,65.07) ; Q33.1 68.46,66.82 v1(69.4,66.82) ; C377.1 82.91,76.88 83.5,76.29 v1(84.72,76.29) ; C422.2 v1(41.56,45.65) ; v1(25.31,90.68) 25.31,89.83 C339.2 ; PC155.2 56.55,70.46 56.99,70.9 v1(57.8,70.9) ; R484.1 R481.1 114.23,67.36 v1(114.46,67.59) ; PC174.2 PC164.2 v1(156.37,67.61) ; PC179.2 v1(156.37,65.58) ; PR162.2 v1(62.9,69.39) ; C242.2 v1(139.48,29.26) ; v1(74.75,64.18) 74.75,64.85 R490.1 ; C352.2 v1(93.25,84) ; v1(167.93,30.28) 167.43,29.78 PC218.1 ; PR227.2 152.31,44.5 v1(152.81,43.99) ; C418.2 v1(46.87,47.18) ; CN11.5 v1(169.96,23.33)
  BOTTOM w0.508: v1(35.32,54.91) 36.14,54.1 C412.2 ; C477.1 C476.2 v1(76.11,16.33) ; C480.2 C473.2 83.21,16.19 v1(83.09,16.31) ; v1(89.57,18.72) 89.58,18.71 C469.2 ; PC122.2 143.8,81.67 v1(143.8,80.82) ; R603.2 91.73,14.93 v1(92.01,14.65) ; C478.1 v1(80.17,16.31) ; v1(34.73,64.69) 34.96,64.46 PR197.2 ; PC212.2 v1(152.69,34.59) ; v1(50.68,59.87) 50.67,59.87 CN7.19 ; PR196.2 33.4,64.07 v1(32.85,64.62) ; v1(39.4,84.76) 40.02,85.37 U20.25 ; C340.2 29.12,89.47 v1(29.5,89.84) ; C472.2 94.77,16.05 v1(95.03,15.8) ; v1(116.24,90.22) C335.2 115.87,90.86 R396.1 ; v1(90.9,14.64) 90.71,14.83 C474.2 ; C336.2 28.37,91.24 27.84,91.77 v1(27.84,92.15) ; CN14.2 158.4,9.32 v1(158.53,9.45) ; v1(35.08,43.89) 35.08,43.56 34.8,43.28 U29.4 ; R566.2 v1(131.48,29.26) ; C347.1 32.04,84.26 v1(31.66,83.87) ; C240.2 v1(136.94,29.26) ; U18.2 112.56,94.66 C7.1 112.47,94.67 v1(111.92,95.22) ; C483.2 168.42,12.37 167.8,12.99 v1(167.8,13.13) ; v1(147.81,57.2) 148.44,57.83 R518.2 ; PR260.2 95.66,15.17 v1(95.66,15.8) 95.66,16.08 95.53,16.21 R594.1 ; R568.2 v1(133.51,29.26) C239.2 ; R579.2 v1(129.95,19.61) ; PC192.1 PC191.1 30.51,59.73 v1(29.62,59.73) ; v1(37.88,60.5) 37.62,60.5 PR213.2 ; R565.2 v1(130.46,29.26) ; v1(79.89,13.59) 80.15,13.33 CN12.4 ; C475.1 v1(74.07,16.31) ; R550.2 26.31,38.79 v1(26.3,38.78) ; v1(139.35,9.57) 139.22,9.45 139.22,8.43 ; v1(82.84,18.77) 83.21,18.4 C468.2 ; PC225.2 141.9,21.27 v1(142.53,21.89) ; R546.2 24.92,42.71 24.91,42.71 v1(24.53,42.34) ; C394.1 115.35,66.84 v1(115.35,66.34) ; U24.2 v1(167.29,55.17) ; PC220.2 144.3,28.09 v1(144.71,28.49) ; C350.2 89.18,83.53 89.26,83.62 v1(89.26,83.92) ; R577.2 127.92,19.62 v1(127.92,19.61) ; C437.1 21.2,32.65 v1(21.37,32.48) ; PR216.2 v1(16.49,59.28) ; CN9.4 17.79,33.7 17.51,33.98 v1(17.2,33.98) ; C416.2 34.44,50.37 v1(34.77,50.7) ; C446.1 40.29,30.89 v1(40.05,31.13) 39.28,30.36 C445.1 ; C450.1 v1(126.4,29.26) ; C341.2 31.79,88.69 v1(31.78,88.7) ; C479.1 v1(82.2,16.31) ; R529.1 70.4,54.91 v1(70.9,54.91) ; v1(169.72,62.3) 170.2,62.78 C396.1 ; C413.1 148.94,53.06 C172.2 ; R480.2 v1(79.65,68.38) ; PC211.2 v1(152.69,35.61) ; C334.2 v1(33.69,92.26) ; C389.2 175.93,70.66 176.67,69.91 v1(177.45,69.91) ; Q34.1 23.65,37.54 v1(23.91,37.79) ; PC186.2 159.29,62.53 v1(158.78,62.03) ; R581.2 v1(131.99,19.61) ; PC173.2 17.98,66.83 18.01,66.85 v1(18.01,66.83) ; C338.2 32.04,90.1 v1(31.78,89.84) ; v1(17.18,33.32) 17.18,32.7 17.43,32.45 CN9.3 ; PR254.2 v1(144.94,19.86) ; PC227.2 146.24,20.15 v1(145.96,19.86) ; SW3.6 65,11.42 v1(65.06,11.48) ; PC140.2 22.32,76.05 v1(22.14,76.23) ; PC226.2 v1(143.92,19.86) ; C449.1 v1(125.38,29.26) ; C435.2 148.75,33.58 v1(148.88,33.45) 148.88,33.19 C436.2 ; C481.2 v1(167.8,14.4) ; v1(100.36,13.77) PC234.2 ; PU11.2 v1(17.92,64.23) ; R556.2 v1(135.92,29.26) ; PR239.2 142.27,28.37 142.89,28.99 v1(142.89,29.26) ; R562.2 v1(127.41,29.26)
  vias: v1(10.19,10.13) v1(15.42,24.05) v1(15.73,25.75) v1(16.54,47.8) v1(18.02,68.5) v1(18.64,67.87) v1(18.65,68.5) v1(19.26,20.96) v1(19.29,19.02) v1(20.07,22.37) v1(20.71,22.36) v1(21.83,97.33) v1(21.83,95.32) v1(25.31,95.3) v1(25.31,93.27) v1(25.43,106.02) v1(26.42,98.78) v1(27.44,32.92) v1(27.46,30.55) v1(27.46,29.64) v1(27.72,93.27) v1(27.97,106.02) v1(29.5,90.98) v1(29.5,88.7) v1(29.55,38.2) v1(30.51,106.02) v1(30.64,90.98) v1(30.64,89.84) v1(30.64,88.7) v1(30.64,36.5) v1(30.77,82.47) v1(30.97,15.54) v1(31.78,90.98) v1(31.78,78.66) v1(31.86,5.43) v1(32.77,77.39) v1(32.85,66.47) v1(33.13,15.85) v1(33.78,65.55) v1(33.84,10.97) v1(34.32,37.01) v1(34.32,36.37) v1(34.32,35.74) v1(34.73,66.47) v1(34.83,84.35) v1(35.39,4.98) v1(35.49,84.35) v1(36.05,38.2) v1(36.05,4.98) v1(36.1,37.51) v1(36.23,39.29) v1(36.68,4.98) v1(37.12,98.22) v1(37.32,4.98) v1(37.62,94.08) v1(37.65,91.11) v1(37.6,88.16) v1(37.95,4.98) v1(40.32,52.75) v1(40.32,49.88) v1(40.7,66.19) v1(41.56,64.18) v1(41.56,51.23) v1(42.22,18.87) v1(42.93,18.87) v1(42.93,18.24) v1(43.24,52.75) v1(43.59,5.76) v1(45.24,10.84) v1(45.7,11.31) v1(48.04,68.5) v1(48.11,48.39) v1(48.19,47.72) v1(49.33,36.12) v1(49.31,35.46) v1(49.31,34.77) v1(49.31,34.09) v1(49.61,25.98) v1(49.62,24.66) v1(49.61,23.51) v1(50.15,30.39) v1(50.15,29.74) v1(50.15,31.06) v1(50.71,83.82) v1(51.34,26.66) v1(51.35,24.38) v1(51.31,22.09) v1(51.34,11.73) v1(52.1,83.87) v1(52.1,18.79) v1(52.1,18.15) v1(52.6,30.32) v1(52.6,29.69) v1(52.75,26.26) v1(52.75,24.1) v1(52.75,22.68) v1(53.25,15.54) v1(53.37,67.49) v1(53.37,65.58) v1(53.44,16.56) v1(53.5,18.79) v1(53.5,18.15) v1(54.31,66.56) v1(54.44,22.93) v1(54.46,24.36) v1(55.28,67.49) v1(55.28,65.58) v1(56.76,30.32) v1(56.78,29.68) v1(56.86,8.37) v1(56.86,7.7) v1(57.02,24.85) v1(57,22.26) v1(57.06,18.79) v1(57.06,18.15) v1(58.18,52.73) v1(58.41,53.41) v1(58.86,52.91) v1(58.96,25.8) v1(58.98,24.17) v1(58.98,22.83) v1(59.09,30.45) v1(59.09,29.74) v1(59.88,18.79) v1(59.88,18.15) v1(60.36,5.36) v1(60.63,25.5) v1(60.63,24.1) v1(61.32,30.39) v1(61.32,29.74) v1(61.3,6.47) v1(61.69,15.28) v1(61.67,14) v1(62.27,26.57) v1(62.26,24.31) v1(62.71,18.79) v1(62.8,16.02) v1(62.9,89.58) v1(62.9,5.36) v1(63.14,14.25) v1(63.2,6.47) v1(63.9,6.48) v1(64.01,89.84) v1(64.04,25.42) v1(64.04,23.95) v1(64.04,22.52) v1(64.68,90.22) v1(65.03,18.77) v1(65.44,5.36) v1(65.95,86.16) v1(66,47.65) v1(66.22,24.23) v1(66.22,22.9) v1(66.51,49.01) v1(66.58,86.16) v1(67.02,47.74) v1(67.02,46.34) v1(67.09,55.29) v1(67.22,86.16) v1(67.29,84.96) v1(67.72,24.56) v1(67.73,22.35) v1(67.85,86.16) v1(67.98,5.36) v1(68.49,86.16) v1(68.47,48.77) v1(68.47,46.74) v1(68.74,76.76) v1(69.02,77.85) v1(69.85,25.67) v1(69.85,24.38) v1(69.86,22.83) v1(69.88,21.45) v1(70.14,77.65) v1(70.14,77.01) v1(70.14,76.38) v1(70.07,49.86) v1(70.07,48.59) v1(70.07,47.32) v1(70.14,11.48) v1(70.52,5.36) v1(70.77,77.65) v1(70.77,77.01) v1(70.9,56.82) v1(70.9,56.18) v1(70.9,55.55) v1(71.02,99.87) v1(71.28,85.52) v1(71.41,78.28) v1(71.41,77.65) v1(71.66,100.63) v1(71.66,99.87) v1(71.74,26.92) v1(71.76,24.31) v1(71.91,85.52) v1(72.04,78.28) v1(72.3,100.63) v1(72.3,99.87) v1(72.3,30.22) v1(72.3,13.77) v1(72.55,85.52) v1(72.68,78.28) v1(72.85,22.02) v1(73.06,5.36) v1(73.18,85.52) v1(73.28,26.8) v1(73.36,78.28) v1(73.61,47.23) v1(73.61,45.96) v1(73.61,44.69) v1(73.64,30.28) v1(73.64,21.99) v1(73.65,23.52) v1(73.82,85.52) v1(74.2,78.41) v1(74.45,85.52) v1(75.46,47.51) v1(75.46,45.48) v1(75.6,5.36) v1(75.88,94.69) v1(76.03,30.43) v1(76.53,24.24) v1(76.53,22.89) v1(76.86,50.59) v1(77.13,47.89) v1(77.13,46.62) v1(77.13,45.35) v1(77.31,51.03) v1(77.5,50.39) v1(77.76,51.48) v1(77.88,87.11) v1(77.99,50.87) v1(78,23.64) v1(78.02,22.18) v1(78.14,5.36) v1(78.26,51.97) v1(78.5,51.37) v1(78.87,82.29) v1(78.96,51.97) v1(79.32,32.63) v1(79.28,30.45) v1(79.46,22.41) v1(79.86,81.18) v1(80.07,87.09) v1(80.17,81.84) v1(80.17,23.97) v1(80.22,21.99) v1(80.5,81.2) v1(80.63,47.17) v1(80.65,45.85) v1(80.65,44.55) v1(80.65,43.18) v1(80.68,5.36) v1(81.04,21.38) v1(81.07,23.61) v1(81.23,81.08) v1(81.82,61.75) v1(82.46,61.75) v1(82.63,81.08) v1(82.58,73.71) v1(82.84,91.74) v1(82.96,25.6) v1(83.22,5.36) v1(83.32,23.87) v1(83.3,22.6) v1(83.67,44.83) v1(83.67,43.56) v1(83.67,42.29) v1(83.73,26.82) v1(84.16,81.08) v1(84.36,7.54) v1(84.72,77.32) v1(85,7.54) v1(85.44,81.2) v1(85.6,26.97) v1(85.63,23.04) v1(85.63,7.54) v1(85.71,56.87) v1(85.76,5.36) v1(86.07,81.2) v1(86.27,7.54) v1(86.52,89.08) v1(86.7,44.35) v1(86.7,43.08) v1(86.7,41.81) v1(86.7,40.54) v1(86.93,94.99) v1(87.15,89.08) v1(87.15,15.21) v1(87.15,10.84) v1(87.28,11.86) v1(87.42,25.27) v1(87.42,23.95) v1(87.51,93.8) v1(87.79,89.08) v1(87.79,10.84) v1(88.03,59.34) v1(88.27,94.84) v1(88.3,5.36) v1(88.42,63.8) v1(88.42,10.84) v1(88.48,44.15) v1(88.48,42.88) v1(88.48,41.61) v1(88.53,25.07) v1(88.75,64.57) v1(88.71,54.32) v1(89.14,23.16) v1(89.44,66.38) v1(89.46,57.43) v1(89.7,55.73) v1(89.69,24.52) v1(90.17,61.78) v1(90.17,59.34) v1(90.41,42.31) v1(90.84,5.36) v1(91.05,78.55) v1(91.09,101.95) v1(91.07,77.91) v1(91.09,60.15) v1(91.53,57.25) v1(91.46,25.8) v1(91.46,24.45) v1(91.45,23.66) v1(91.46,22.27) v1(92.23,101.95) v1(92.27,66.47) v1(92.29,61.75) v1(92.31,59.31) v1(92.54,44.37) v1(92.54,43.1) v1(92.54,41.83) v1(92.65,58.73) v1(92.83,26.41) v1(92.83,23.82) v1(92.83,22.41) v1(93.38,5.36) v1(93.59,66.9) v1(93.59,61.12) v1(94.77,43.13) v1(94.77,41.86) v1(94.77,40.59) v1(94.89,25.88) v1(94.89,24.53) v1(95.04,21.86) v1(95.05,70.76) v1(95.11,62.56) v1(95.12,59.67) v1(95.07,23.2) v1(95.92,5.36) v1(96.09,41.6) v1(96.64,61.11) v1(96.6,26.17) v1(96.6,24.69) v1(96.6,22) v1(96.76,72.9) v1(96.76,72.19) v1(96.76,70.76) v1(96.76,70.05) v1(97.46,39.39) v1(98.38,40.56) v1(98.46,5.36) v1(98.74,70.13) v1(98.79,70.79) v1(98.92,66.19) v1(98.92,65.46) v1(98.92,64.01) v1(98.92,61.11) v1(98.92,25.63) v1(98.92,24.26) v1(98.9,22.78) v1(99.6,82.55) v1(99.68,61.12) v1(100.11,18.72) v1(100.44,82.95) v1(100.45,66.19) v1(100.57,72.21) v1(101,91.36) v1(101,5.36) v1(101.1,26.77) v1(101.11,25.43) v1(101.11,23.91) v1(101.09,22.55) v1(101.2,12.14) v1(101.63,84.89) v1(101.97,61.84) v1(102.14,13.77) v1(102.14,13.13) v1(102.14,12.5) v1(102.78,13.77) v1(102.95,26.9) v1(102.98,24.79) v1(103.15,54.4) v1(103.33,87.17) v1(103.26,61.78) v1(103.41,13.77) v1(103.54,5.36) v1(103.89,84.81) v1(103.97,62.69) v1(103.97,61.78) v1(104.3,35.1) v1(104.3,13.77) v1(104.3,12.55) v1(104.4,26.36) v1(104.39,24.95) v1(104.39,23.57) v1(104.68,66.44) v1(104.68,62.69) v1(104.65,13.16) v1(104.81,34.59) v1(104.93,13.77) v1(105.06,14.65) v1(105.32,34.09) v1(105.39,66.44) v1(105.57,13.82) v1(105.82,33.58) v1(106.13,66.42) v1(106.1,62.69) v1(106.08,5.36) v1(106.2,78.28) v1(106.2,77.27) v1(106.33,33.07) v1(106.81,62.69) v1(106.84,32.56) v1(107.14,22.32) v1(107.15,25.17) v1(107.16,23.76) v1(107.35,32.05) v1(107.53,62.69) v1(107.5,21.61) v1(107.86,31.55) v1(108.22,66.47) v1(108.62,5.36) v1(109.18,69.65) v1(109.48,24.58) v1(109.48,21.96) v1(109.53,20.7) v1(110.22,43.12) v1(110.27,68.88) v1(110.28,45.15) v1(110.67,26.16) v1(110.7,23.82) v1(110.7,22.38) v1(110.78,82.35) v1(110.81,18.72) v1(111.16,5.36) v1(111.41,7.29) v1(111.48,74.87) v1(111.49,69.7) v1(111.49,59.97) v1(111.69,72.85) v1(111.66,37.18) v1(111.77,29.74) v1(111.86,42.54) v1(112.08,63.11) v1(112.24,36.85) v1(112.27,37.49) v1(112.45,58.15) v1(112.63,63.42) v1(113.27,70.69) v1(113.44,90.73) v1(113.44,90.09) v1(113.39,59.97) v1(113.7,5.36) v1(113.8,72.82) v1(113.85,42.21) v1(114.08,90.73) v1(114.08,90.09) v1(114.33,91.46) v1(114.71,10.34) v1(114.94,73.48) v1(115.35,10.34) v1(115.96,73.46) v1(115.98,10.34) v1(116.24,5.36) v1(116.62,10.34) v1(117.13,68.73) v1(117.15,73.48) v1(117.68,84.15) v1(117.76,95.81) v1(117.76,86.03) v1(117.76,82.22) v1(118.14,77.77) v1(118.47,73.51) v1(118.78,5.36) v1(119.67,86.03) v1(119.67,84.12) v1(119.67,82.22) v1(119.92,77.77) v1(120.43,72.26) v1(121.11,77.77) v1(121.19,93.01) v1(121.32,5.36) v1(121.53,40.26) v1(121.57,86.03) v1(121.57,84.12) v1(121.57,82.19) v1(121.64,37.62) v1(122.46,10.34) v1(122.8,40.26) v1(123.12,11.07) v1(123.1,10.34) v1(123.35,94.28) v1(123.63,4.54) v1(123.67,37.62) v1(123.73,10.34) v1(124.01,94.97) v1(124.07,40.26) v1(124.44,95.55) v1(124.44,27.05) v1(124.39,25.02) v1(124.87,93.27) v1(124.87,92.51) v1(125.51,93.27) v1(126.59,63.02) v1(126.91,64.16) v1(127.16,82.22) v1(127.64,77.57) v1(127.79,82.22) v1(127.91,64.57) v1(128.3,75.61) v1(128.3,62.05) v1(128.43,82.22) v1(128.35,64.11) v1(128.73,64.62) v1(128.94,75.61) v1(128.94,65.45) v1(129.06,82.22) v1(129.57,75.61) v1(129.7,82.22) v1(130.11,96.47) v1(130.21,75.61) v1(131.02,63.35) v1(132.49,63.35) v1(135.13,37.05) v1(135.29,72.57) v1(135.29,71.55) v1(135.29,70.53) v1(135.92,26.21) v1(135.9,24.18) v1(136.3,72.57) v1(136.3,71.55) v1(136.3,70.53) v1(136.56,22.78) v1(136.76,2.92) v1(137.29,45.06) v1(138.72,16.81) v1(140.24,72.95) v1(140.75,71.93) v1(140.88,72.95) v1(141.76,74.85) v1(141.89,77.93) v1(141.88,77.16) v1(141.87,76.33) v1(143.26,65.07) v1(144.3,24.69) v1(144.3,23.67) v1(144.44,60.64) v1(144.81,24.18) v1(145.2,60.64) v1(145.98,60.64) v1(147.61,21.16) v1(148.65,26.59) v1(148.62,21.13) v1(148.88,57.2) v1(148.88,56.56) v1(149.26,21.13) v1(149.51,66.98) v1(149.51,66.34) v1(149.51,57.2) v1(149.51,56.56) v1(149.51,55.93) v1(150.15,21.77) v1(150.27,78.28) v1(150.4,71.68) v1(150.65,33.2) v1(150.65,21.13) v1(151.16,33.58) v1(151.16,32.56) v1(151.29,21.13) v1(151.42,78.03) v1(151.67,71.68) v1(152.64,68.4) v1(152.76,67.59) v1(152.76,66.62) v1(152.76,65.76) v1(152.81,21.13) v1(153.02,84.17) v1(153.07,71.68) v1(153.45,21.13) v1(153.96,8.94) v1(153.96,8.3) v1(154.48,80.95) v1(154.62,8.63) v1(154.84,71.52) v1(155.23,80.95) v1(156.04,70.1) v1(156.37,8.63) v1(156.78,71.7) v1(156.88,43.23) v1(158.21,46.05) v1(158.21,45.41) v1(158.85,46.05) v1(159.04,78.79) v1(159.09,71.73) v1(159.16,47.66) v1(159.16,9.45) v1(159.3,46.51) v1(159.29,41.71) v1(159.42,80.95) v1(159.39,42.7) v1(159.54,48.17) v1(159.54,47.13) v1(159.52,44.78) v1(159.67,31.93) v1(160.5,33.32) v1(160.5,32.69) v1(160.69,65.58) v1(160.69,58.29) v1(160.69,31.42) v1(160.69,30.78) v1(161.14,84.17) v1(161.12,33.2) v1(161.12,32.56) v1(161.07,31.93) v1(161.32,31.04) v1(161.37,70.03) v1(161.7,32.94) v1(161.7,32.31) v1(161.7,31.67) v1(161.93,57.48) v1(161.93,30.2) v1(161.98,70.99) v1(162.29,58.05) v1(162.59,57.48) v1(162.59,56.82) v1(162.85,12.62) v1(164.12,43.99) v1(164.12,42.47) v1(164.5,62.66) v1(164.5,61.64) v1(164.5,52.55) v1(164.5,51.92) v1(164.75,59.1) v1(164.75,56.95) v1(164.75,55.8) v1(164.88,43.23) v1(165.64,43.99) v1(165.64,42.47) v1(166.02,19.1) v1(166.02,18.46) v1(166.02,17.83) v1(166.02,16.05) v1(166.02,15.29) v1(166.02,14.65) v1(166.28,65.96) v1(166.66,59.99) v1(167.29,17.83) v1(167.8,22.15) v1(167.8,21) v1(167.8,19.35) v1(169.45,84.15) v1(169.83,16.05) v1(170.85,59.99) v1(170.85,59.36) v1(171.48,53.39) v1(171.63,57.02) v1(171.66,59.08) v1(171.99,84.15) v1(172.24,53.41) v1(172.24,26.64) v1(172.6,64.18) v1(172.83,54) v1(175.14,84.15) v1(175.17,81.58) v1(177.58,19.86) v1(177.58,17.99) v1(177.58,16.05) v1(179.1,70.92) v1(179.48,19.86) v1(179.48,17.99) v1(179.48,16.05) v1(181.39,19.86) v1(181.39,17.99) v1(181.39,16.05) v1(183.5,7.34) v2(8.87,5.87) v2(8.87,0.94) v2(13.37,0.94) v2(14.03,11.99) v2(14.31,82.83) v2(14.31,80.06) v2(14.31,70.44) v2(14.31,67.97) v2(14.31,65.45) v2(14.31,62.89) v2(14.31,60.32) v2(14.31,57.94) v2(14.31,52.78) v2(14.31,50.16) v2(14.31,47.72) v2(14.31,45.11) v2(14.31,42.57) v2(14.31,37.82) v2(14.31,34.67) v2(14.31,32.43) v2(14.31,29.89) v2(14.31,24.81) v2(14.31,22.27) v2(14.31,19.73) v2(14.31,17.19) v2(14.31,14.53) v2(18.19,0.94) v2(21.83,107.06) v2(21.83,104.44) v2(21.83,101.93) v2(21.83,99.39) v2(22.89,0.94) v2(23.48,107.16) v2(28.48,0.94) v2(29.83,75.79) v2(29.85,76.53) v2(30.59,76.55) v2(30.56,75.79) v2(31.32,76.58) v2(31.3,75.79) v2(31.6,99.52) v2(31.66,98.6) v2(31.68,97.74) v2(31.71,96.82) v2(31.73,95.78) v2(32.04,75.82) v2(32.11,76.55) v2(32.32,95.1) v2(32.85,75.82) v2(32.87,76.58) v2(33,107.11) v2(33.43,0.94) v2(35.54,107.11) v2(38.08,107.11) v2(38.64,0.94) v2(40.43,3.25) v2(40.67,71.42) v2(40.67,70.66) v2(40.67,69.9) v2(40.67,69.14) v2(40.67,68.38) v2(41.43,71.42) v2(42.32,71.42) v2(42.32,64.31) v2(42.27,5.23) v2(42.45,69.77) v2(42.45,68.25) v2(42.45,65.07) v2(47.84,70.69) v2(47.83,69.9) v2(47.78,66.98) v2(52.22,81.71) v2(54.09,83.49) v2(54.77,84.17) v2(61.37,76.25) v2(61.37,75.49) v2(61.37,74.73) v2(61.37,73.2) v2(62.14,76.63) v2(62.14,75.87) v2(62.14,75.11) v2(62.14,74.34) v2(62.14,73.58) v2(62.14,72.82) v2(62.9,75.74) v2(62.9,74.98) v2(62.9,74.22) v2(62.9,73.46) v2(62.9,72.69) v2(63.02,76.63) v2(63.66,75.74) v2(63.66,74.98) v2(63.66,74.22) v2(63.66,73.46) v2(63.66,72.69) v2(64.42,75.49) v2(64.42,74.73) v2(64.42,73.96) v2(64.45,73.18) v2(71.76,104.63) v2(89,100.52) v2(92.23,104.57) v2(94.77,100.25) v2(95.38,94.74) v2(110.32,100.52) v2(112.43,104.7) v2(114.71,102.67) v2(129.55,98.96) v2(130.72,98.6) v2(131.86,103.94) v2(131.86,102.41) v2(135.64,100.07) v2(135.67,101.78) v2(135.67,98.47) v2(135.67,95.93) v2(135.67,93.39) v2(135.67,90.85) v2(135.85,86.26) v2(136.81,18.85) v2(136.81,1.81) v2(137.57,18.85) v2(137.57,18.08) v2(137.57,17.32) v2(137.83,85.19) v2(138.28,18.51) v2(138.26,17.7) v2(139.35,1.81) v2(140.37,85.19) v2(141.23,78.15) v2(141.23,77.39) v2(141.23,76.63) v2(141.89,1.81) v2(142.91,85.19) v2(144.43,1.81) v2(145.07,85.19) v2(146.97,1.81) v2(149.51,1.81) v2(149.87,27.9) v2(149.87,27.15) v2(150.56,28.55) v2(150.63,27.79) v2(150.63,27.02) v2(151.19,28.93) v2(151.26,28.17) v2(151.26,27.4) v2(151.26,26.64) v2(152.05,1.81) v2(154.59,1.81) v2(157.13,1.81) v2(159.67,1.81) v2(162.21,1.81) v2(164.75,1.81) v2(167.29,1.81) v2(169.83,1.81) v2(172.37,1.81) v2(174.91,1.81) v2(175.17,79.73) v2(175.17,77.24) v2(177.45,75.61) v2(187.19,12.75) v2(187.19,10.21) v2(187.19,7.67) v2(187.19,5.13)
