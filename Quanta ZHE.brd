# Allegro board Quanta ZHE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DMIC_CLK_C: length 3
  TOP w0.14: v1(150.7,81.05) 150.53,80.87 R55.2
  BOTTOM w0.14: CN5.40 151.98,80.63 151.57,81.05 v1(150.7,81.05)
DMIC_CLK_R: length 2.7
  TOP w0.14: R355.2 177.58,12.76 177.58,13.79 178.08,14.29 U16.3
DMIC_DAT: length 131.7
  TOP w0.14: D2.2 152.56,80.69 v1(153.07,81.2) ; R354.2 176.3,11.72 v1(175.8,11.23)
  IN1 w0.089: v1(175.8,11.23) 175.8,11.76 175.21,12.35 172.77,12.35 169.15,8.74 161.15,8.74 159.79,10.1 159.79,13.66 160.58,14.46 160.96,14.46 165.25,18.75 165.25,20.23 166.98,21.96 166.98,29.85 164.83,31.99 164.83,35.29 166.33,36.78 166.33,41.27 167.18,42.13 167.18,50.01 167.63,50.46 167.63,51.04 172.43,55.84 172.43,59.9 170.82,61.52 170.82,68.09 174.17,71.45 174.17,75.49 173.58,76.09 173.58,79.04 172.94,79.68 170.86,79.68 170.77,79.59 170.77,79.06 170.68,78.97 170.5,78.97 170.41,79.06 170.41,79.59 170.32,79.68 170.15,79.68 170.06,79.59 170.06,79.08 169.97,78.99 169.79,78.99 169.7,79.08 169.7,79.59 169.61,79.68 169.43,79.68 169.35,79.59 169.35,79.08 169.26,78.99 169.08,78.99 168.99,79.08 168.99,79.59 168.9,79.68 168.72,79.68 168.63,79.59 168.63,79.06 168.55,78.97 168.37,78.97 168.28,79.06 168.28,79.59 168.19,79.68 168.01,79.68 167.92,79.59 167.92,79.06 167.83,78.97 167.66,78.97 167.57,79.06 167.57,79.59 167.48,79.68 167.3,79.68 167.21,79.59 167.21,79.08 167.12,78.99 166.94,78.99 166.86,79.08 166.86,79.59 166.77,79.68 166.59,79.68 166.5,79.59 166.5,79.06 166.41,78.97 166.23,78.97 166.14,79.06 166.14,79.59 166.06,79.68 165.88,79.68 165.79,79.59 165.79,79.08 165.7,78.99 165.52,78.99 165.43,79.08 165.43,79.59 165.34,79.68 157.74,79.68 156.07,81.35 153.21,81.35 v1(153.07,81.2)
  BOTTOM w0.14: CN5.39 152.48,80.62 v1(153.07,81.2)
DMIC_DAT_R: length 3
  TOP w0.14: R354.1 176.31,12.85 v1(176.77,13.31) 177.14,13.68 177.14,13.72 177.68,14.27 U16.2
DNBSWON#: length 89.5
  TOP w0.127: R261.2 24.67,43.87 24.67,45.87 24.9,46.09 24.9,47.22 25.16,47.48 25.7,47.48 26.48,46.7 33.32,46.7 33.76,47.15 34.61,47.15 35.31,47.84 36.13,47.84 36.54,48.25 36.54,48.43 38.2,50.09 39.12,50.09 44.05,55.01 46.67,55.01 47.4,54.29 48.08,54.29 48.47,53.9 49.06,53.9 R187.1 50.27,53.39 52.04,51.61 v1(52.99,51.61) 53.15,51.61 v1(54.98,49.78)
  IN1 w0.089: v1(83.98,73.96) 83.19,74.75 82.43,74.75 81.51,75.67 81.13,75.67 80.75,75.29 80.75,71.91 76.64,67.8 71.75,67.8 69.8,65.85 66.45,65.85 64.91,64.32 63.3,64.32 61.74,62.76 61.74,61.88 61.05,61.18 60.68,61.18 60.23,60.72 60.23,60.36 57.88,58.01 57.88,55.75 55.93,53.8 55.93,52.39 54.98,51.45 v1(54.98,49.78)
  BOTTOM w0.089: 85.12,73.74 85.32,73.74 85.44,73.62 86.22,73.62 U22.E54
  BOTTOM w0.14: 85.12,73.74 84.21,73.74 v1(83.98,73.96)
DNBSWON#_R: length 3
  TOP w0.127: R261.1 25.43,42.33 25.43,42.09 v1(25.81,41.71) 26.07,41.45 26.07,41.07 26.31,40.82 U14.123
DUALDMIC_PWR: length 3.6
  TOP w0.381: R57.2 R58.2 165.12,80.95 v1(165.51,80.95)
  BOTTOM w0.254: CN5.12 165.98,80.56 165.59,80.95 v1(165.51,80.95)
EC_FPBACK#: length 229.6
  TOP w0.127: U14.86 39.32,34.38 39.34,34.4 43.86,34.4 45.63,32.64 v1(45.63,32.51) ; v1(155.99,78.79) 155.99,77.27 157,76.25 Q5.2
  IN3 w0.127: v1(155.99,78.79) 156.9,77.87 173.47,77.87 173.9,77.44 173.9,76.16 174.86,75.21 174.86,71.11 171.8,68.05 171.8,62.24 172.8,61.23 172.8,56.42 162.66,46.27 162.66,37.52 161.64,36.51 161.64,34.94 162.51,34.06 162.51,31.24 161.36,30.08 160.24,30.08 160.01,30.31 157.84,30.31 157.05,31.1 149.75,31.1 149.27,30.61 147.97,30.61 147.31,29.95 144.22,29.95 141.3,27.04 128.78,27.04 128,26.26 128,23.22 125.61,20.83 121.92,20.83 120.11,19.03 120.11,19.02 116.31,15.23 105.03,15.23 104.27,14.46 93.67,14.46 92.78,15.35 87.43,15.35 85.22,13.14 74.77,13.14 73.55,11.92 56.82,11.92 55.04,13.7 49.77,13.7 46.75,16.72 46.75,20.98 44.5,23.23 44.5,24.89 45.63,26.02 v1(45.63,32.51)
EC_PWROK: length 130.5
  TOP w0.127: v1(98.87,80.06) 98.77,79.96 98.36,79.96 97.62,79.22 97.62,78.49 R68.1
  TOP w0.14: U14.33 24.31,25.09 24.54,25.32 26.38,25.32 26.42,25.28 30.18,25.28 v1(30.53,25.63)
  IN1 w0.089: v1(98.87,80.06) 98.87,79.62 99.07,79.42 99.07,78.38 98.38,77.7 95.82,77.7 92.57,80.95 91.59,80.95 90.08,82.47 85.38,82.47 83.15,84.69 83.15,86 81.02,88.14 76.53,88.14 75.74,87.35 75.74,84.47 77.11,83.1 77.11,81.03 75.86,79.78 70.37,79.78 68.77,78.18 68.77,71.34 63.98,66.55 61.27,66.55 59.96,65.24 59.96,64.89 55.53,60.47 55.53,59.1 54.85,58.42 54.85,55.88 53.21,54.25 51.75,54.25 51.33,53.82 v1(50.58,53.82)
  IN3 w0.127: v1(50.58,53.82) 50.9,53.5 50.9,49.41 49.77,48.29 49.77,42.93 48.29,41.45 48.29,40.44 47.33,39.47 47.33,38.82 45.67,37.17 42.99,37.17 33.33,27.51 32.41,27.51 v1(30.53,25.63)
ECAGND: length 11.8
  TOP w0.203: 39.36,29.98 U14.75
  TOP w0.254: 39.36,29.98 40.17,29.17 42.92,29.17 43.47,28.62 C257.2
  TOP w0.508: C257.2 43.97,27.61 44.23,27.86 v1(44.74,27.86) 45.24,27.86 45.49,27.61 L8.2 44.26,26.34 C261.1
EDP_AUXN: length 74.1
  IN3 w0.089: 111.08,63.19 111.06,63.18 111.06,63.13 110.23,62.29 105.94,62.29 104.33,63.9 104.01,63.9 102.86,65.06 102.86,65.79 103.09,66.03 103.55,66.03 v1(103.92,66.4)
  IN3 w0.127: 111.08,63.19 112.13,64.25 118.91,64.25 120.51,65.84 121.9,65.84 122.06,65.68 130.77,65.68 131.88,64.57 143.67,64.57 144.38,63.85 154.77,63.85 156.05,65.14 158.33,65.14 158.85,65.65 158.85,67.6 160.51,69.26 160.7,69.26 v1(160.96,69.51)
  BOTTOM w0.089: U22.W15 103.57,66.84 103.57,66.58 103.75,66.4 v1(103.92,66.4)
  BOTTOM w0.14: v1(160.96,69.51) 161.2,69.26 162.24,69.26 162.59,69.62 162.59,70.8 R472.2 162.59,71.81 162.59,73.07 C386.1
EDP_AUXN_C: length 5.8
  BOTTOM w0.14: CN5.19 162.48,79.12 162.59,79.02 162.59,74.6 C386.2
EDP_AUXP: length 74.1
  IN3 w0.089: 111.28,63.04 111.24,63 111.19,63 110.31,62.12 105.86,62.12 104.25,63.73 103.94,63.73 102.68,64.99 102.68,65.87 103.17,66.36 v1(103.17,66.45)
  IN3 w0.127: 111.28,63.04 112.24,63.99 119.02,63.99 120.61,65.59 121.79,65.59 121.95,65.43 130.66,65.43 131.78,64.31 143.56,64.31 144.28,63.6 154.87,63.6 156.16,64.88 158.44,64.88 159.1,65.55 159.1,67.49 160.61,69 160.7,69 v1(160.96,68.75)
  BOTTOM w0.089: v1(103.17,66.45) 102.9,66.72 U22.W17
  BOTTOM w0.14: v1(160.96,68.75) 161.2,69 162.35,69 162.86,69.51 162.86,70.81 R473.2 162.85,71.81 162.85,73.07 C387.1
EDP_AUXP_C: length 5.9
  BOTTOM w0.14: C387.2 162.85,74.6 162.85,78.99 162.98,79.12 CN5.18
EDP_HPD_R: length 6.4
  TOP w0.127: R67.2 163.98,77.79 v1(163.98,75.74) 163.35,75.74 163.1,75.49 Q4.2
  BOTTOM w0.127: R449.1 C376.2 163.61,76.11 v1(163.98,75.74)
EDP_HPD_R_C: length 2.9
  BOTTOM w0.127: CN5.16 163.98,79.29 163.8,79.11 163.8,78.32 v1(163.91,78.2) 164.6,77.52 R449.2
EDP_RCOMP_N: length 1.4
  TOP w0.14: v1(106.85,66.45) 106.85,67.17 R114.1
  BOTTOM w0.089: U22.AA7 107.17,66.18 106.91,66.45 v1(106.85,66.45)
EDP_RCOMP_P: length 1.4
  TOP w0.14: R114.2 107.61,66.53 v1(107.53,66.45)
  BOTTOM w0.089: U22.AA5 107.88,66.1 v1(107.53,66.45)
EDP_TXN0: length 71.1
  IN3 w0.089: v1(103.97,64.61) 104.26,64.91 104.26,65.07 104.43,65.23 105.03,65.23 105.26,65 105.26,64.21 106.2,63.27 109.4,63.27 109.59,63.08 110.27,63.08 110.76,63.56 110.87,63.68 110.87,63.93 111.09,64.15 111.09,64.2 111.1,64.22
  IN3 w0.127: 111.1,64.22 111.88,64.99 118.69,64.99 120.23,66.54 122.17,66.54 122.34,66.37 147.5,66.37 149.33,64.54 154.48,64.54 155.61,65.66 155.61,66.7 156.08,67.17 157.45,67.17 159.82,69.54 159.82,70.53 160.19,70.9 160.56,70.9 v1(160.84,71.18)
  BOTTOM w0.089: v1(103.97,64.61) 104.32,64.26 U22.AE13
  BOTTOM w0.14: v1(160.84,71.18) 161.11,70.92 161.21,70.92 161.29,71 161.29,74.25 160.8,74.74 160.8,75.24 C380.1
EDP_TXN0_C: length 3.8
  BOTTOM w0.14: C380.2 160.81,76.77 160.81,77.54 161.1,77.83 161.1,79.01 160.98,79.12 CN5.22
EDP_TXN1: length 68.9
  IN3 w0.089: v1(103.26,65.53) 103.4,65.53 103.81,65.94 105.26,65.94 105.7,65.5 105.7,64.45 106.37,63.78 108.77,63.78 110.1,65.11 110.1,66.01 110.06,66.05 110.06,66.06
  IN3 w0.127: v1(158.75,71.18) 158.57,70.99 158.31,70.99 157.35,70.03 157.35,69.62 154.92,67.19 154.92,65.94 154.2,65.22 149.62,65.22 147.79,67.05 122.63,67.05 122.46,67.22 119.95,67.22 118.4,65.68 114.04,65.68 112.74,66.97 110.4,66.97 110.06,66.63 110.06,66.06
  BOTTOM w0.089: v1(103.26,65.53) U22.AC17
  BOTTOM w0.14: C384.1 159.54,73.07 159.54,71.16 159.31,70.93 159,70.93 v1(158.75,71.18)
EDP_TXN1_C: length 5.9
  BOTTOM w0.14: C384.2 159.54,74.6 159.54,77.97 159.6,78.03 159.6,79.01 159.48,79.12 CN5.25
EDP_TXN2: length 64
  IN3 w0.089: v1(106.81,64.61) 106.55,64.34 106.55,64.26 106.59,64.21 108.49,64.21 108.82,64.54 108.82,65.27 109.35,65.81 109.35,65.95 109.32,65.99
  IN3 w0.127: 109.32,65.99 109.32,66.86 110.9,68.44 114.38,68.44 116.48,70.53 120.12,70.53 122.91,67.74 149.66,67.74 150.22,68.3 155.04,68.3 156.62,69.88 156.62,70.89 156.95,71.22 157.15,71.22 v1(157.39,71.45)
  BOTTOM w0.089: U22.AE8 106.46,64.26 v1(106.81,64.61)
  BOTTOM w0.14: v1(157.39,71.45) 157.66,71.18 157.78,71.18 157.98,71.38 157.98,75.39 C378.1
EDP_TXN2_C: length 3.7
  BOTTOM w0.14: CN5.28 157.98,79.12 158.14,78.97 158.14,76.76 C378.2
EDP_TXN3: length 59.5
  IN3 w0.127: v1(155.52,71.32) 155.26,71.05 154.47,71.05 153.65,70.24 153.65,69.17 153.47,68.98 149.93,68.98 149.38,68.43 123.2,68.43 120.4,71.22 116.19,71.22 114.1,69.12 111.17,69.12 110.71,69.58 109.98,69.58 109.57,69.17 109.57,68.18 108.64,67.25 108.64,66.3 107.75,65.42 107.75,64.84 v1(107.53,64.61)
  BOTTOM w0.089: U22.AE7 107.17,64.26 v1(107.53,64.61)
  BOTTOM w0.14: C382.1 156.62,73.07 156.62,72.85 156,72.23 156,71.18 155.89,71.07 155.77,71.07 v1(155.52,71.32)
EDP_TXN3_C: length 5.8
  BOTTOM w0.14: C382.2 156.6,74.58 156.6,79.01 156.48,79.12 CN5.31
EDP_TXP0: length 71.1
  IN3 w0.089: v1(104.68,64.61) 104.44,64.85 104.44,64.99 104.5,65.06 104.96,65.06 105.09,64.93 105.09,64.13 106.13,63.09 109.32,63.09 109.52,62.9 110.35,62.9 110.88,63.43 111.05,63.6 111.05,63.86 111.21,64.02 111.27,64.02 111.28,64.04
  IN3 w0.127: v1(160.84,70.42) 160.62,70.64 160.29,70.64 160.08,70.43 160.08,69.44 157.55,66.91 156.18,66.91 155.86,66.59 155.86,65.55 154.59,64.28 149.23,64.28 147.4,66.11 122.24,66.11 122.07,66.28 120.34,66.28 118.79,64.74 111.98,64.74 111.28,64.04
  BOTTOM w0.089: v1(104.68,64.61) 104.68,64.53 U22.AE12
  BOTTOM w0.14: C381.1 161.13,75.29 161.07,75.22 161.07,74.85 161.56,74.36 161.56,70.89 161.32,70.65 161.07,70.65 v1(160.84,70.42)
EDP_TXP0_C: length 3.8
  BOTTOM w0.14: C381.2 161.08,76.75 161.08,77.43 161.37,77.72 161.37,79.01 161.48,79.12 CN5.21
EDP_TXP1: length 68.9
  IN3 w0.089: v1(103.97,65.53) 104.2,65.76 105.19,65.76 105.52,65.43 105.52,64.38 106.3,63.6 108.84,63.6 110.28,65.03 110.28,66 110.31,66.04 110.31,66.06
  IN3 w0.127: 110.31,66.06 110.31,66.52 110.51,66.72 112.63,66.72 113.93,65.42 118.51,65.42 120.05,66.97 122.35,66.97 122.52,66.8 147.68,66.8 149.51,64.97 154.31,64.97 155.18,65.84 155.18,67.08 157.61,69.51 157.61,69.93 158.42,70.74 158.65,70.74 158.75,70.64 v1(158.75,70.41)
  BOTTOM w0.089: v1(103.97,65.53) 103.87,65.63 103.8,65.63 103.66,65.48 103.66,65.09 U22.AC15
  BOTTOM w0.14: C385.1 159.8,73.07 159.8,71.05 159.42,70.66 159,70.66 v1(158.75,70.41)
EDP_TXP1_C: length 5.9
  BOTTOM w0.14: CN5.24 159.98,79.12 159.87,79.01 159.87,77.92 159.8,77.86 159.8,74.6 C385.2
EDP_TXP2: length 64.9
  IN3 w0.089: 109.58,65.96 109.53,65.92 109.53,65.73 109,65.2 109,64.46 108.57,64.03 106.52,64.03 106.37,64.18 106.37,64.34 v1(106.1,64.61)
  IN3 w0.127: v1(157.39,70.69) 157.39,70.79 157.21,70.97 157.06,70.97 156.88,70.78 156.88,69.77 155.15,68.04 150.32,68.04 149.77,67.49 122.81,67.49 120.01,70.28 116.58,70.28 114.49,68.18 111,68.18 109.58,66.76 109.58,65.96
  BOTTOM w0.089: U22.AE10 105.75,64.26 v1(106.1,64.61)
  BOTTOM w0.14: v1(157.39,70.69) 157.61,70.91 157.89,70.91 158.25,71.27 158.25,75.28 158.57,75.61 C379.1
EDP_TXP2_C: length 3.7
  BOTTOM w0.14: CN5.27 158.48,79.1 158.41,79.02 158.41,76.76 C379.2
EDP_TXP3: length 59.5
  IN3 w0.127: v1(108.24,64.61) 108.01,64.84 108.01,65.31 108.89,66.19 108.89,67.15 109.82,68.08 109.82,69.07 110.08,69.33 110.61,69.33 111.06,68.87 114.2,68.87 116.3,70.97 120.3,70.97 123.09,68.17 149.48,68.17 150.04,68.73 153.58,68.73 153.91,69.06 153.91,70.13 154.57,70.8 155.28,70.8 v1(155.52,70.55)
  BOTTOM w0.089: v1(108.24,64.61) 107.88,64.26 U22.AE5
  BOTTOM w0.14: v1(155.52,70.55) 155.77,70.8 156,70.8 156.27,71.07 156.27,72.12 156.88,72.73 156.88,73.07 C383.1
EDP_TXP3_C: length 5.9
  BOTTOM w0.14: CN5.30 156.98,79.12 156.87,79.01 156.87,74.62 C383.2
EDP_VDD_EN: length 8.9
  TOP w0.127: R59.2 157.95,79.61 U7.3 155.67,79.61 155.35,79.3 155.35,76.89 v1(155.8,76.44) 156.17,76.07 R620.2
EMMC_CLK: length 82.6
  IN3 w0.089: 103.09,75.23 103.09,74.41 103.18,74.32 103.18,73.55 103.6,73.14 103.6,72.02 104.05,71.57 104.05,71.48 v1(104.07,71.46)
  IN3 w0.127: 103.09,75.23 103.09,75.25 100.16,78.18 99.57,78.18 98.26,79.49 97.45,79.49 97.3,79.34 96.57,79.34 94.76,81.14 91.99,81.14 90.98,82.15 89.54,82.15 87.35,84.34 77.63,84.34 77.53,84.44 65.97,84.44 64.95,83.43 64.95,72.8 61.56,69.4 61.56,59.68 60.04,58.16 60.04,55.91 60.89,55.07 60.89,53.5 62.65,51.74 v1(62.66,51.74)
  BOTTOM w0.089: v1(104.07,71.46) 104.41,71.12 U22.J13
  BOTTOM w0.14: v1(62.66,51.74) 62.89,51.5 U26.M6
EMMC_CMD: length 87.3
  TOP w0.14: v1(63.39,51.74) 62.91,52.22 v1(60.6,52.22) 60.12,51.74 R198.2
  IN3 w0.089: v1(104.07,70.1) 103.57,70.6 103.57,71.79 103.42,71.95 103.42,73.06 102.93,73.55 102.93,74.04 102.71,74.26 102.71,74.91 102.39,75.23
  IN3 w0.127: v1(63.39,51.74) 62.21,52.92 62.21,54.46 61.63,55.04 61.63,56.06 62.78,57.21 62.78,58.59 62.07,59.29 62.07,69.19 65.46,72.59 65.46,83.22 66.18,83.93 76.8,83.93 76.91,83.83 80.83,83.83 81.23,83.42 82.87,83.42 83.16,83.71 87.26,83.71 89.32,81.65 90.77,81.65 91.78,80.63 93.39,80.63 94.86,79.16 95.86,79.16 96.19,78.83 97.23,78.83 98.39,77.67 99.95,77.67 102.39,75.23
  BOTTOM w0.089: v1(104.07,70.1) 104.47,69.7 U22.M13
  BOTTOM w0.14: U26.M5 v1(63.39,51.74)
EMMC_DATA_0: length 82.7
  TOP w0.14: TP14.1 101.72,68.93 v1(102.13,69.34)
  IN3 w0.089: 100.36,70.28 101,70.28 101.94,69.34 v1(102.13,69.34)
  IN3 w0.127: v1(66.05,59.31) 66.13,59.31 66.64,59.82 66.64,64.98 68.25,66.59 68.25,66.75 67.96,67.04 67.96,67.18 68.18,67.4 68.32,67.4 68.76,66.96 68.9,66.96 69.12,67.17 69.12,67.32 67.96,68.47 67.96,68.62 68.18,68.83 68.32,68.83 68.78,68.38 68.92,68.38 69.14,68.59 69.14,68.74 68.08,69.8 68.08,69.94 68.29,70.16 68.44,70.16 69.45,69.14 69.6,69.14 69.81,69.36 69.81,69.5 68.8,70.52 68.8,70.66 69.01,70.88 69.15,70.88 70.1,69.94 70.91,69.94 71.87,68.98 76.23,68.98 77.89,70.64 78.39,71.39 78.74,72.22 78.91,73.11 78.91,74.01 78.74,74.9 78.72,74.94 78.72,76.15 78.62,76.25 78.19,76.25 78.09,76.35 78.09,76.66 78.19,76.76 78.62,76.76 78.72,76.86 78.72,77.34 77.81,78.25 77.81,78.39 78.02,78.61 78.17,78.61 79.12,77.66 79.3,77.66 79.54,77.9 79.75,77.9 79.88,78.03 79.88,78.7 79.98,78.8 80.28,78.8 80.38,78.7 80.38,77.72 80.49,77.62 80.79,77.62 80.89,77.72 80.89,78.37 80.99,78.47 81.3,78.47 81.4,78.37 81.4,77.96 81.5,77.86 81.81,77.86 81.91,77.96 81.91,78.37 82.01,78.48 82.32,78.48 82.42,78.37 82.42,78.03 82.54,77.9 85.3,77.9 85.75,78.35 85.9,78.35 86.11,78.14 86.11,77.99 85.66,77.54 85.66,77.36 86.84,76.19 87.57,76.19 87.69,76.31 87.69,76.97 87.8,77.07 88.1,77.07 88.2,76.97 88.2,76.31 88.33,76.19 89.43,76.19 89.63,75.98 89.63,75.53 89.89,75.27 92.45,75.27 93.05,74.67 96.36,74.67 97.72,73.31 97.72,70.28 98.36,69.65 98.97,69.65 99.6,70.28 100.36,70.28
  BOTTOM w0.089: v1(102.13,69.34) 101.77,69.7 U22.M19 ; 64.39,57.04 U26.A3
  BOTTOM w0.14: v1(66.05,59.31) 66.05,58.7 64.39,57.04
EMMC_DATA_1: length 81.8
  IN3 w0.089: 100.54,75.23 101.71,74.06 101.71,72.67 v1(102.12,72.26)
  IN3 w0.127: 100.54,75.23 100.31,75.46 100.31,75.66 99.31,76.66 97.97,76.66 96.81,77.81 95.77,77.81 95.44,78.14 94.34,78.14 93.25,79.23 92.81,79.23 92.43,79.61 90.37,79.61 89.81,80.17 88.82,80.17 86.68,82.31 80.33,82.31 79.85,82.8 78.95,82.8 78.82,82.68 78.82,82.47 78.72,82.37 78.42,82.37 78.31,82.47 78.31,82.68 78.19,82.8 77.93,82.8 77.81,82.68 77.81,82.4 77.7,82.3 77.4,82.3 77.3,82.4 77.3,82.68 77.17,82.8 76.92,82.8 76.79,82.68 76.79,82.09 76.55,81.85 70.84,81.85 67.09,78.1 67.09,77.56 66.96,77.43 66.61,77.43 66.48,77.31 66.48,77.05 66.61,76.93 66.96,76.93 67.09,76.8 67.09,76.54 66.96,76.42 66.61,76.42 66.48,76.29 66.48,76.04 66.61,75.91 66.96,75.91 67.09,75.78 67.09,75.53 66.96,75.4 66.61,75.4 66.48,75.27 66.48,75.02 66.61,74.89 66.96,74.89 67.09,74.77 67.09,74.51 66.96,74.39 66.61,74.39 66.48,74.26 66.48,74 66.61,73.88 66.96,73.88 67.09,73.75 67.09,73.5 66.96,73.37 66.61,73.37 66.48,73.24 66.48,72.99 66.61,72.86 66.96,72.86 67.09,72.73 67.09,72.56 63.85,69.32 63.85,67.21 63.09,66.45 63.09,60.69 63.43,60.34 63.43,60.16 63.13,59.86 63.13,59.68 63.31,59.5 63.49,59.5 63.73,59.74 64.01,59.74 64.22,59.53 v1(64.22,59.27)
  BOTTOM w0.089: U22.H19 101.69,71.84 v1(102.12,72.26)
  BOTTOM w0.14: v1(64.22,59.27) 64.54,58.95 64.78,58.95 65.01,59.18 65.01,60.6 66.21,61.81 66.44,61.81 66.59,61.66 66.59,61.45 65.54,60.4 65.54,58.57 64.07,57.1 64.07,56.92 U26.A4
EMMC_DATA_2: length 81.8
  IN3 w0.089: 100.36,74.8 100.46,74.7 100.64,74.7 101.38,73.96 101.38,71.77 101.7,71.45 102.1,71.45 v1(102.13,71.47)
  IN3 w0.127: 100.36,74.8 100.21,74.95 98.95,74.95 98.78,75.12 98.78,75.3 99.27,75.79 99.27,75.93 99.05,76.15 98.91,76.15 98.42,75.66 98.24,75.66 96.65,77.25 94.51,77.25 93.04,78.73 92.6,78.73 92.22,79.11 90.16,79.11 89.6,79.67 88.61,79.67 86.47,81.81 85.16,81.81 85.04,81.68 85.04,81.39 84.91,81.26 84.65,81.26 84.53,81.39 84.53,81.68 84.4,81.81 83.76,81.81 83.63,81.68 83.63,81.24 83.53,81.14 83.22,81.14 83.12,81.24 83.12,81.68 83,81.81 82.27,81.81 82.15,81.68 82.15,81.26 82.04,81.16 81.74,81.16 81.64,81.26 81.64,81.68 81.51,81.81 79.86,81.81 79.75,81.92 79.75,82.18 79.63,82.29 79.36,82.29 79.24,82.18 79.24,81.92 79.13,81.81 77.83,81.81 76.86,80.83 76.65,80.83 76.55,80.94 76.55,81.24 76.45,81.34 76.12,81.34 76.04,81.27 76.04,80.94 75.94,80.83 75.66,80.83 75.53,80.96 75.53,81.27 75.46,81.34 75.1,81.34 75.03,81.27 75.03,80.94 74.92,80.83 74.65,80.83 74.52,80.96 74.52,81.27 74.44,81.34 74.11,81.34 74.01,81.24 74.01,80.94 73.91,80.83 73.63,80.83 73.5,80.96 73.5,81.24 73.4,81.34 73.1,81.34 72.99,81.24 72.99,80.96 72.87,80.83 72.61,80.83 72.49,80.96 72.49,81.24 72.39,81.34 72.08,81.34 71.98,81.24 71.98,80.96 71.85,80.83 71.6,80.83 71.47,80.96 71.47,81.24 71.37,81.34 71.06,81.34 70.96,81.24 70.96,80.96 70.84,80.83 70.54,80.83 67.6,77.89 67.6,72.34 64.89,69.63 64.89,69.06 64.76,68.93 64.43,68.93 64.36,68.86 64.36,68.5 64.43,68.42 64.76,68.42 64.89,68.3 64.89,67.54 63.6,66.24 63.6,64.37 64.1,63.87 64.1,62.47 63.96,62.32 63.67,62.32 63.6,62.24 63.6,61.89 63.67,61.81 64.51,61.81 64.58,61.74 64.58,61.38 64.51,61.31 63.67,61.31 63.6,61.23 63.6,60.9 63.7,60.8 64.5,60.8 64.58,60.72 64.58,60.31 64.5,60.22 v1(64.4,60.22)
  BOTTOM w0.089: U22.J19 101.77,71.12 v1(102.13,71.47)
  BOTTOM w0.14: U26.A5 63.39,57.26 63.25,57.4 63.11,57.4 62.97,57.54 62.97,57.82 63.11,57.96 63.25,57.96 63.39,58.1 63.39,58.38 63.25,58.52 63.11,58.52 62.97,58.66 62.97,58.94 63.11,59.08 63.5,59.08 63.64,59.21 63.64,59.66 63.3,59.99 63.3,60.14 63.55,60.39 63.7,60.39 64.03,60.05 64.23,60.05 v1(64.4,60.22)
EMMC_DATA_3: length 81.8
  IN3 w0.089: 100.36,68.88 101,68.88 101.65,68.23 102.65,68.23 v1(102.89,68.46)
  IN3 w0.127: 100.36,68.88 99.88,68.88 99.3,68.3 98.95,68.3 98.82,68.17 98.82,67.26 98.7,67.13 98.44,67.13 98.31,67.26 98.31,68.17 98.19,68.3 97.93,68.3 97.81,68.17 97.81,67.26 97.7,67.16 97.4,67.16 97.3,67.26 97.3,68.17 97.01,68.46 96.83,68.46 96.35,67.99 96.17,67.99 96,68.17 96,68.35 96.47,68.82 96.47,69 96.37,69.1 95.64,69.1 95.51,69.23 95.51,69.48 95.64,69.61 96.2,69.61 96.31,69.71 96.31,70.74 96.18,70.87 95.69,70.87 95.56,71 95.56,71.25 95.69,71.38 96.18,71.38 96.31,71.5 96.31,71.87 95.13,73.05 94.59,73.05 94.46,72.92 94.46,69.75 94.36,69.65 94.05,69.65 93.95,69.75 93.95,72.92 93.82,73.05 93.12,73.05 91.91,74.25 91.3,74.25 90.94,73.89 88.8,73.89 88.69,74.01 88.69,74.69 88.58,74.79 88.28,74.79 88.18,74.69 88.18,73.99 88.08,73.89 87.77,73.89 87.67,73.99 87.67,74.66 87.54,74.79 86.8,74.79 86.62,74.97 86.44,74.97 85.98,74.51 85.83,74.51 85.62,74.72 85.62,74.87 86.08,75.33 86.08,75.51 85.87,75.72 84.66,75.72 84.13,76.25 84.03,76.25 83.91,76.12 83.91,75.69 83.78,75.56 83.53,75.56 83.4,75.69 83.4,76.12 83.27,76.25 80.64,76.25 79.93,75.54 79.93,73.01 79.72,71.93 79.29,70.91 78.68,69.99 76.65,67.96 72.36,67.96 71.61,67.21 71.61,66.39 68.61,63.4 68.61,63.07 68.51,62.97 68.14,62.97 68.04,62.87 68.04,62.56 68.14,62.46 68.51,62.46 68.61,62.36 68.61,62.06 68.51,61.95 68.14,61.95 68.04,61.85 68.04,61.55 68.14,61.45 68.51,61.45 68.61,61.34 68.61,61.04 68.51,60.94 67.76,60.94 67.66,60.84 67.66,60.53 67.76,60.43 68.34,60.43 68.44,60.33 68.44,60.02 68.34,59.92 67.76,59.92 67.66,59.82 67.66,58.63 67.13,58.1 67.13,57.92 67.42,57.62 67.42,57.48 67.21,57.26 67.06,57.26 66.77,57.56 66.59,57.56 66.47,57.44 66.47,57.13 v1(66,56.66)
  BOTTOM w0.086: 65.57,56.49 65.14,56.49
  BOTTOM w0.089: v1(102.89,68.46) 102.85,68.46 102.57,68.74 U22.P17 ; 65.14,56.49 U26.B2
  BOTTOM w0.14: v1(66,56.66) 65.83,56.49 65.57,56.49
EMMC_DATA_4: length 81.9
  IN3 w0.089: 100.36,69.77 101,69.77 102.13,68.64 v1(102.13,68.63)
  IN3 w0.127: 100.36,69.77 99.93,69.77 99.19,69.04 98.15,69.04 97.21,69.98 97.21,73.1 96.15,74.16 95.47,74.16 95.39,74.09 95.39,73.66 95.29,73.56 94.98,73.56 94.88,73.66 94.88,74.06 94.78,74.16 94.48,74.16 94.37,74.06 94.37,73.64 94.27,73.54 93.97,73.54 93.87,73.64 93.87,74.09 93.79,74.16 92.78,74.16 92.18,74.76 90.86,74.76 90.75,74.66 90.75,74.5 90.65,74.4 90.35,74.4 90.25,74.5 90.25,74.66 90.14,74.76 89.84,74.76 89.74,74.66 89.74,74.5 89.64,74.4 89.33,74.4 89.23,74.5 89.23,75.19 89.13,75.3 87.01,75.3 85.5,76.81 84.33,76.81 84.2,76.93 84.2,77.27 84.08,77.39 83.82,77.39 83.7,77.27 83.7,76.93 83.57,76.81 82.54,76.81 82.39,76.96 82.39,77.27 82.26,77.39 82.01,77.39 81.88,77.27 81.88,76.96 81.73,76.81 80.43,76.81 79.87,77.37 79.73,77.37 79.51,77.15 79.51,77.01 80.02,76.51 80.02,76.35 79.63,75.96 79.23,75.56 79.23,75.05 79.42,74.06 79.42,73.06 79.23,72.07 78.84,71.15 78.29,70.31 76.44,68.47 72.15,68.47 71.99,68.31 71.81,68.31 70.7,69.43 70.55,69.43 70.34,69.21 70.34,69.07 71.47,67.94 71.47,67.79 71.26,67.58 71.11,67.58 69.99,68.7 69.85,68.7 69.63,68.48 69.63,68.34 71.1,66.87 71.1,66.73 70.88,66.51 70.74,66.51 70.27,66.98 70.09,66.98 69.91,66.8 69.91,66.62 70.44,66.09 70.44,65.95 70.23,65.73 70.08,65.73 69.44,66.38 69.29,66.38 69.08,66.16 69.08,66.02 69.72,65.37 69.72,65.23 69.51,65.01 69.36,65.01 68.45,65.92 68.31,65.92 68.09,65.71 68.09,65.56 69,64.65 69,64.51 68.79,64.29 68.65,64.29 67.73,65.21 67.59,65.21 67.37,64.99 67.37,64.85 68.25,63.97 68.25,63.82 68.04,63.61 67.89,63.61 67.51,63.99 67.37,63.99 67.15,63.77 67.15,63.63 67.47,63.31 67.47,63.13 67.15,62.81 67.15,59.06 v1(66.1,58.01)
  BOTTOM w0.086: 64.64,56.88 64.64,56.37
  BOTTOM w0.089: U26.B3 64.51,56.24 64.64,56.37 ; U22.P19 101.77,68.99 v1(102.13,68.63)
  BOTTOM w0.14: v1(66.1,58.01) 65.77,58.01 64.64,56.88
EMMC_DATA_5: length 82.6
  IN3 w0.089: 102.57,73.76 102.57,71.81 v1(103.03,71.36)
  IN3 w0.127: 102.57,73.76 102.1,74.23 102.1,74.41 102.3,74.62 102.3,74.8 102.12,74.97 101.94,74.97 101.74,74.77 101.56,74.77 100.82,75.51 100.82,75.87 99.53,77.16 98.18,77.16 97.02,78.32 95.98,78.32 95.65,78.65 94.65,78.65 93.18,80.12 90.62,80.12 90.06,80.68 89.03,80.68 86.89,82.82 81.12,82.82 80.62,83.32 76.72,83.32 76.3,82.9 76.06,82.9 75.93,83.03 75.93,83.26 75.8,83.39 75.55,83.39 75.42,83.26 75.42,83.03 75.3,82.9 75.04,82.9 74.92,83.03 74.92,83.26 74.79,83.39 74.53,83.39 74.41,83.26 74.41,83.03 74.28,82.9 74.03,82.9 73.9,83.03 73.9,83.26 73.77,83.39 73.52,83.39 73.39,83.26 73.39,83.03 73.26,82.9 73.01,82.9 72.88,83.03 72.88,83.26 72.76,83.39 72.5,83.39 72.38,83.26 72.38,83.03 72.25,82.9 71.99,82.9 71.87,83.03 71.87,83.26 71.74,83.39 71.49,83.39 71.36,83.26 71.36,83.03 71.23,82.9 70.79,82.9 70.35,83.34 70.17,83.34 69.99,83.16 69.99,82.98 70.43,82.54 70.43,82.36 69.74,81.68 69.56,81.68 69.4,81.84 69.22,81.84 69.04,81.66 69.04,81.48 69.2,81.32 69.2,81.14 68.85,80.79 68.67,80.79 68.5,80.96 68.32,80.96 68.14,80.78 68.14,80.6 68.31,80.43 68.31,80.25 67.42,79.36 67.24,79.36 67.04,79.55 66.9,79.56 66.68,79.34 66.68,79.2 66.88,79 66.88,78.82 66.7,78.64 66.52,78.64 66.33,78.83 66.19,78.83 65.97,78.61 65.97,78.47 66.16,78.28 66.16,78.1 65.97,77.91 65.97,72.16 63.34,69.53 63.34,68.85 63.21,68.73 62.74,68.73 62.62,68.6 62.62,68.35 62.74,68.22 63.21,68.22 63.34,68.09 63.34,67.42 62.58,66.66 62.58,59.5 63.28,58.8 63.28,56.15 63.87,55.56 v1(63.87,54.74)
  BOTTOM w0.086: 64.14,55 64.14,55.99
  BOTTOM w0.089: 64.14,55.99 63.9,56.24 U26.B4 ; v1(103.03,71.36) 103.27,71.12 U22.J15 ; v1(63.87,54.74) 64.14,55
EMMC_DATA_6: length 81.8
  IN3 w0.089: 100.36,74.17 100.67,74.17 101.1,73.73 101.1,71.79 101.98,70.91 v1(102.13,70.76)
  IN3 w0.127: 100.36,74.17 100.08,74.45 98.74,74.45 96.44,76.74 94.3,76.74 93.58,77.47 92.15,77.47 92.02,77.6 92.02,78.46 91.9,78.59 91.64,78.59 91.52,78.46 91.52,77.6 91.39,77.47 90.38,77.47 90.29,77.55 90.29,77.73 90.64,78.07 90.64,78.25 90.46,78.43 90.28,78.43 89.94,78.09 89.76,78.09 89.63,78.22 89.63,78.9 89.37,79.16 88.4,79.16 86.93,80.63 79.49,80.63 79.37,80.76 79.37,81.2 79.27,81.3 78.96,81.3 78.86,81.2 78.86,80.76 78.73,80.63 78.48,80.63 78.35,80.76 78.35,81.1 78.25,81.2 77.94,81.2 77.84,81.1 77.84,80.76 77.72,80.63 77.38,80.63 77.07,80.33 70.75,80.33 68.1,77.68 68.1,72.13 66.44,70.46 66.44,69.49 66.34,69.39 65.5,69.39 65.4,69.29 65.4,68.98 65.5,68.88 66.34,68.88 66.44,68.78 66.44,68.48 66.34,68.38 65.5,68.38 65.4,68.27 65.4,67.97 65.5,67.87 66.34,67.87 66.44,67.77 66.44,67.46 66.34,67.36 65.5,67.36 65.4,67.26 65.4,66.95 65.5,66.85 65.85,66.85 65.95,66.75 65.95,66.44 65.85,66.34 64.42,66.34 64.31,66.24 64.31,65.94 64.42,65.84 64.88,65.84 64.98,65.73 64.98,65.43 64.88,65.33 64.21,65.33 64.1,65.23 64.1,64.92 64.21,64.82 64.88,64.82 65.09,64.61 65.09,59.5 64.46,58.87 64.46,58.69 64.93,58.22 64.93,58.06 64.76,57.88 64.55,57.88 64.14,58.29 63.97,58.29 63.79,58.11 v1(63.79,58.06)
  BOTTOM w0.086: 63.64,56.97 63.64,56.46
  BOTTOM w0.089: U26.B5 63.42,56.24 63.64,56.46 63.64,56.46 ; 63.64,57.11 63.64,56.97 ; U22.L17 102.49,70.41 v1(102.13,70.76)
  BOTTOM w0.14: v1(63.79,58.06) 63.79,58.63 63.94,58.77 64.24,58.77 64.7,58.31 64.7,58.17 63.64,57.11
EMMC_DATA_7: length 82.5
  IN3 w0.089: 100.36,70.66 101.12,70.66 101.71,70.08 102.27,70.08 102.94,69.41 v1(102.94,69.35)
  IN3 w0.127: 100.36,70.66 99.5,70.66 99.22,70.94 99.22,71.93 99.02,72.13 98.41,72.13 98.23,72.31 98.23,73.52 96.57,75.18 93.42,75.18 92.14,76.45 89.88,76.45 89.23,77.1 88.79,77.1 87.23,78.66 86.85,78.66 86.53,78.98 85.4,78.98 85.27,79.11 85.27,79.42 85.17,79.53 84.87,79.53 84.76,79.42 84.76,79.11 84.64,78.98 83.81,78.98 83.69,79.11 83.69,79.37 83.56,79.5 83.3,79.5 83.18,79.37 83.18,79.11 83.05,78.98 82.38,78.98 82.25,79.11 82.25,79.4 82.15,79.5 81.85,79.5 81.75,79.4 81.75,79.11 81.62,78.98 81.11,78.98 80.78,79.31 79.15,79.31 79.02,79.18 79.02,78.99 78.89,78.87 78.64,78.87 78.51,78.99 78.51,79.18 78.38,79.31 77.71,79.31 77.59,79.18 77.59,78.89 77.49,78.79 77.18,78.79 77.08,78.89 77.08,79.18 76.95,79.31 76.7,79.31 76.57,79.18 76.57,78.92 76.47,78.81 76.16,78.81 76.06,78.92 76.06,79.18 75.94,79.31 75.68,79.31 75.56,79.18 75.56,78.92 75.45,78.81 75.15,78.81 75.05,78.92 75.05,79.18 74.92,79.31 74.67,79.31 74.54,79.18 74.54,78.95 74.44,78.85 74.13,78.85 74.03,78.95 74.03,79.18 73.9,79.31 73.65,79.31 73.52,79.18 73.52,78.89 73.42,78.79 73.12,78.79 73.02,78.89 73.02,79.18 72.89,79.31 72.63,79.31 72.51,79.18 72.51,78.89 72.41,78.79 72.1,78.79 72,78.89 72,79.18 71.87,79.31 71.17,79.31 69.6,77.74 69.6,77.47 69.48,77.34 69.22,77.34 69.12,77.24 69.12,76.93 69.22,76.83 69.55,76.83 69.65,76.73 69.65,76.43 69.55,76.32 69.25,76.32 69.12,76.2 69.12,75.94 69.25,75.82 69.55,75.82 69.65,75.71 69.65,75.41 69.55,75.31 69.25,75.31 69.12,75.18 69.12,74.93 69.25,74.8 69.53,74.8 69.63,74.7 69.63,74.39 69.53,74.29 69.25,74.29 69.12,74.17 69.12,73.91 69.25,73.78 69.53,73.78 69.63,73.68 69.63,73.38 69.53,73.28 69.25,73.28 69.12,73.15 69.12,72.9 69.25,72.77 69.58,72.77 69.68,72.67 69.68,72.36 69.58,72.26 69.22,72.26 69.12,72.16 69.12,71.71 67.46,70.04 67.46,66.51 66.14,65.19 66.14,60.12 66.13,60.12 v1(66.13,60.11)
  BOTTOM w0.086: 63.14,56.88 63.14,56.47
  BOTTOM w0.089: 63.14,56.47 62.91,56.24 U26.B6 ; v1(102.94,69.35) 102.94,69.41 102.65,69.7 U22.M17
  BOTTOM w0.14: 63.14,56.88 62.65,57.37 62.65,60.22 63.34,60.91 64.34,60.91 65.77,62.33 66.66,62.33 67.11,61.87 67.11,61.09 v1(66.13,60.11)
EMMC_ID0: length 35.5
  TOP w0.127: R133.2 R136.1 66.06,61.4 v1(66.07,61.39) 68.05,59.41 v1(68.1,59.41)
  IN1 w0.089: v1(92.37,65.51) 92.37,65.54 91.75,66.16 91.75,66.82 91.24,67.32 90.78,67.32 90.15,67.95 86.53,67.95 85.44,66.86 84.08,66.86 84.02,66.8 83.97,66.75 81.91,66.75 81.34,66.18 81.34,65.41 80.32,64.39 80.11,64.39 77.25,61.52 77.25,60.88 76.99,60.63 74.43,60.63 73.3,59.5 68.2,59.5 v1(68.1,59.41)
  BOTTOM w0.089: U22.AC39 92.66,65.22 v1(92.37,65.51)
EMMC_ID1: length 30.2
  IN1 w0.114: v1(68.49,54.66) 69.7,54.66 70.13,54.23 73.53,54.23 79.66,60.35 79.66,61.81 80.71,62.86 80.88,62.86 81.74,63.72 84.2,63.72 84.79,64.31 85.51,64.31 86.62,65.42 90.06,65.42 v1(90.17,65.53)
  BOTTOM w0.089: v1(90.17,65.53) U22.AC44
  BOTTOM w0.127: R527.1 69.89,55.44 69.62,55.17 69.62,54.92 R529.2 69.37,54.66 v1(68.49,54.66)
EMMC_ID2: length 29.1
  TOP w0.127: v1(73.51,58.61) 72.79,58.61 72.42,58.98 72.42,59.75 R156.1 71.39,59.71 70.42,59.71 v1(69.88,60.25) R155.2
  IN1 w0.114: v1(90.91,66.47) 90.74,66.47 89.89,67.31 86.8,67.31 85.7,66.22 84.34,66.22 84.25,66.13 82.89,64.78 81.3,64.78 80.47,63.94 80.26,63.94 78.58,62.26 78.58,60.76 76.28,58.47 73.65,58.47 v1(73.51,58.61)
  BOTTOM w0.089: v1(90.91,66.47) 90.91,66.39 U22.AA44
EMMC_RCLK: length 80.5
  TOP w0.14: v1(66.07,55.03) 66.07,54.8 R183.1 R188.2
  IN3 w0.089: v1(103.01,70.69) 102.62,70.31 101.94,70.31 101.29,70.95 100.36,70.95
  IN3 w0.127: 100.36,70.95 100.32,70.95 100.11,71.17 100.11,73.15 99.85,73.4 99.78,73.4 99.17,74.01 98.45,74.01 96.23,76.24 95.36,76.24 95.27,76.15 95.27,75.79 95.17,75.69 94.87,75.69 94.76,75.79 94.76,76.13 94.66,76.24 94.09,76.24 93.37,76.96 90.12,76.96 89.48,77.61 89,77.61 87.44,79.17 87.1,79.17 86.21,80.06 77.53,80.06 77.28,79.82 70.96,79.82 68.61,77.47 68.61,71.92 66.95,70.25 66.95,66.72 65.6,65.37 65.6,57.49 65.37,57.26 63.89,57.26 63.79,57.16 63.79,56.85 63.89,56.75 65.37,56.75 65.49,56.63 65.49,56.37 65.37,56.24 64.62,56.24 64.52,56.14 64.52,55.84 64.62,55.74 65.39,55.74 65.49,55.64 65.49,55.33 65.39,55.23 64.68,55.23 64.57,55.13 64.57,54.82 64.68,54.72 65.36,54.72 65.46,54.62 65.46,54.31 65.36,54.21 64.73,54.21 64.62,54.11 64.62,53.14 64.83,52.93 65.82,52.93 66.07,53.19 v1(66.07,55.03)
  BOTTOM w0.089: v1(103.01,70.69) 103.29,70.41 U22.L15
EMMC_RCLK_R: length 1.6
  TOP w0.14: v1(63.91,52.96) 64.41,52.96 R188.1
  BOTTOM w0.254: U26.H5 63.63,53.24 v1(63.91,52.96)
EMMC_RCOMP: length 2.5
  TOP w0.254: v1(103.54,71.8) 103.54,71.25 v1(104.02,70.76) 104.29,70.76 R98.1
  BOTTOM w0.254: v1(104.02,70.76) 104.12,70.76 U22.L13
EMMC_RST: length 51.4
  TOP w0.127: R190.1 55.79,52.88 55.61,52.7 55.61,51.28 55.91,50.98 55.91,49.84 56.86,48.89 v1(61.5,48.89)
  IN1 w0.089: v1(90.95,67.99) 90.83,67.87 90.51,67.87 90.23,68.14 86.45,68.14 86.43,68.12 85.07,68.12 83.89,66.94 81.78,66.94 81.15,66.31 81.15,65.49 80.31,64.64 80.1,64.64 77.38,61.92 75.74,61.92 74.82,60.99 74.08,60.99 72.94,59.85 67.83,59.85 66.55,58.57 66.55,56.54 65.44,55.42 65.44,53.01 62.9,50.47 62.25,50.47 61.5,49.71 v1(61.5,48.89)
  BOTTOM w0.089: U22.U44 v1(90.95,67.99)
EN: length 2.5
  BOTTOM w0.127: R581.1 R580.2 130.45,21.53 U32.7
EQ1: length 5
  BOTTOM w0.127: U32.18 129.95,26.85 129.45,27.35 R564.2 R565.1 130.97,28.36 v1(130.97,29.64)
EQ2: length 4.1
  BOTTOM w0.127: R567.2 R566.1 131.48,27.61 131.73,27.35 v1(131.73,26.97) 131.73,26.97 130.59,26.97 130.45,26.83 U32.19
EQ_SEL_A0: length 3.3
  TOP w0.127: U6.5 123.06,83.52 123.48,83.11 v1(123.86,83.11) R43.2 124.74,82.59 124.61,82.46 R45.1
FAN1_DAC: length 18.3
  TOP w0.127: 37.37,32.38 36.66,31.67 35.84,31.67 34.96,32.55
  TOP w0.14: v1(24.75,32.1) 24.82,32.17 31.38,32.17 31.76,32.55 34.96,32.55 ; 37.37,32.38 U14.81
  BOTTOM w0.127: v1(24.75,32.1) 23.65,33.2 U31.4 22.69,33.91 v1(22.26,34.34)
FAN1_RPM: length 27
  TOP w0.14: U14.47 29.91,22.92 v1(29.67,22.68)
  IN1 w0.089: v1(29.67,22.68) 27.69,24.66 v1(27.69,26.06)
  BOTTOM w0.14: v1(27.69,26.06) 27.69,26.49 27.38,26.8 27.38,28.29 26.04,29.64 26.04,34.02 24.38,35.67 21.05,35.67 20.99,35.73 R551.2 C434.2 19.98,34.73 19.54,34.29 19.54,31.39 19.35,31.2 CN9.2
FAN2_RPM: length 7.5
  TOP w0.127: R251.1 35.95,43.81 35.35,44.42 34.82,44.42 34.26,43.86 v1(33.56,43.86) 33.04,43.86 32.38,43.2 32.38,42.06 32.31,41.99 U14.108
FB_VCGI: length 6
  BOTTOM w0.127: PU10.24 54.71,63.34 PC185.2 55.79,62.26 PC189.2 PR214.1 56.29,60.88 v1(56.67,61.26) 56.8,61.39 PR204.1
FB_VNN: length 7.5
  TOP w0.203: PU1.24 33.38,62.1 33.15,61.87 33.15,61.35 PR53.1 32.67,60.65 v1(33.08,60.25)
  BOTTOM w0.127: v1(31.78,58.98) 32.43,59.62 PC195.2
  BOTTOM w0.203: PR53.1 32.67,60.65 v1(33.08,60.25) 32.67,59.84 PC195.2 PR219.1
G5335-AGND-1: length 11.7
  TOP w0.254: v1(147.61,77.52) 147.07,77.52 146.92,77.67 146.92,80.62 146.72,80.82 v1(146.34,80.82) v1(145.7,80.82)
  BOTTOM w0.254: v1(145.7,80.82) 145.7,81.71 145.96,81.97 PC123.2 ; PR142.2 PR139.2 PC135.2 PR138.2 147.97,76.88 147.61,77.24 v1(147.61,77.52) 147.47,77.65 PU6.4
G5335-BST-1: length 2.2
  TOP w0.508: v1(144.43,80.82) 144.43,81.14 PR5.2
  BOTTOM w0.254: v1(144.43,80.82) 144.44,80.82 PU6.20
G5335-EN-1: length 4.1
  TOP w0.127: PR6.1 148,79.18 v1(147.61,78.79)
  BOTTOM w0.127: PU6.2 147.47,78.65 v1(147.61,78.79) 148.12,78.79 v1(148.37,78.54) 149.26,77.66 PC135.1
G5335-FB-1: length 4.5
  BOTTOM w0.254: PR142.1 150.15,75.1 149.38,75.88 PC139.1 PR141.2 147.48,76.64 147.48,76.81 147.14,77.15 PU6.5
G5335-LX-1: length 0.6
  TOP w0.508: PC11.1 v1(141.76,78.79)
  vias: v1(141.89,80.82)
G5335-PFM-1: length 3
  TOP w0.254: PR8.1 148.29,77.6 148.24,77.6 147.69,78.15 v1(147.61,78.15)
  BOTTOM w0.254: PU6.3 147.6,78.15 v1(147.61,78.15) 147.74,78.15 PR138.1
G5335-PWRGD-1: length 3.3
  TOP w0.127: PR7.1 149.01,79.68 147.86,79.68 v1(147.61,79.42)
  BOTTOM w0.127: v1(147.61,79.42) 147.48,79.42 147.2,79.15 PU6.1
G5335-SS-1: length 1.5
  BOTTOM w0.254: PC123.1 146.34,80.69 145.93,80.29 PU6.23
G5335-TON-1: length 2.8
  BOTTOM w0.254: PU6.6 147.1,76.24 147.1,76 v1(147.35,75.74) 147.1,75.49 147.1,74.72 PR146.1
G5335-VCC-1: length 5.1
  TOP w0.508: PR4.2 143.87,83.23 144.55,82.56 144.85,82.56 v1(145.07,82.35) v1(145.07,80.82)
  BOTTOM w0.254: PU6.21 144.93,80.69 v1(145.07,80.82)
  BOTTOM w0.508: v1(145.07,80.82) 145.07,81.67 PC122.1
G5719LX2.5V:
  vias: v1(112.17,13.89)
G_MBCLK_R: length 6.3
  TOP w0.14: R373.2 R374.1 91.47,9.7 v1(92.09,10.32) 93.34,11.57 93.34,12.54 93.56,12.76 U17.4
G_MBDATA_R: length 4.1
  TOP w0.14: R375.2 R376.1 v1(94.52,10.11) 94.52,10.59 95.04,11.11 U17.6
GPA5: length 2.9
  TOP w0.127: TP39.1 22.13,24.94 21.72,25.35 21.72,26.26 21.84,26.38
  TOP w0.14: U14.31 21.84,26.38
GPC6: length 289.4
  TOP w0.127: U14.124 25.91,40.84 24.87,41.88 24.37,41.88 23.91,42.34 23.91,43.26 R248.1 23.15,44.03 23.15,45.93 23.4,46.19 R221.2 24.04,46.19 24.64,46.79 24.64,47.9 v1(24.8,48.06) 25.49,48.06 26.58,46.96 33.21,46.96 33.65,47.4 34.5,47.4 35.2,48.1 36.02,48.1 36.28,48.36 36.28,48.53 38.09,50.34 39.02,50.34 43.94,55.27 50.45,55.27 51.21,54.5 51.21,53.29 v1(52.29,52.21)
  IN3 w0.127: v1(52.29,52.21) 52.31,52.2 52.31,48.84 52.1,48.64 52.1,44.65 53.47,43.28 53.47,42.5 49.08,38.1 48.58,38.1 46.9,36.41 46.9,34.09 46.07,33.27 46.07,26.1 44.76,24.79 44.76,23.33 47.01,21.08 47.01,16.83 49.06,14.77 54.33,14.77 56.93,12.18 73.45,12.18 75.3,14.03 85.75,14.03 87.32,15.61 92.89,15.61 93.78,14.72 104.16,14.72 104.92,15.48 116.21,15.48 119.86,19.13 119.86,19.14 121.81,21.09 125.51,21.09 127.74,23.33 127.74,26.36 128.67,27.29 140.81,27.29 142.1,28.57 142.1,29.54 142.38,29.83 143.73,29.83 144.11,30.21 147.2,30.21 147.86,30.87 149.16,30.87 149.65,31.35 157.16,31.35 157.95,30.57 160.12,30.57 160.34,30.34 161.25,30.34 162.26,31.34 162.26,33.96 161.39,34.83 161.39,36.61 162.4,37.63 162.4,46.38 172.55,56.53 172.55,61.13 171.55,62.13 171.55,68.16 174.61,71.22 174.61,75.1 173.65,76.06 173.65,77.34 173.37,77.62 154.12,77.62 152.95,78.79 v1(152.94,78.79)
  BOTTOM w0.127: v1(152.94,78.79) 152.98,78.83 CN5.38
GPD7: length 2.8
  TOP w0.14: TP40.1 30.31,21.64 U14.48
GPE0: length 3.8
  TOP w0.127: U14.19 21.92,31.18 21.31,30.57 19.81,30.57 TP35.1
GPE7: length 2.3
  TOP w0.127: TP36.1 20.82,30.31 21.46,30.31 21.92,30.78 U14.20
GPF6: length 1.7
  TOP w0.127: 28.71,40.77 28.1,41.38 TP24.1
  TOP w0.14: U14.117 28.71,40.77
GPH0: length 4.6
  TOP w0.127: R282.2 42.14,37.9 v1(41.43,37.9) 39.82,37.9 39.1,37.18 U14.93
GPH1: length 4.3
  TOP w0.127: TP31.1 41.56,39.04 40.76,38.24 39.76,38.24 39.1,37.58
  TOP w0.14: U14.94 39.1,37.58
GPH2: length 2.9
  TOP w0.127: U14.95 39.1,37.98 39.62,38.5 40.27,38.5 TP30.1
GPH3: length 1.4
  TOP w0.127: TP29.1 39.4,38.83 38.95,38.38 U14.96
GPH4: length 2.5
  TOP w0.127: TP25.1 37.39,40.74 36.84,40.74 36.71,40.62 U14.97
GPH5: length 3.1
  TOP w0.127: U14.98 36.31,40.77 36.53,41 37.14,41 37.24,41.1 v1(37.62,41.1) 37.65,41.07 R274.2
GPH6: length 5.2
  TOP w0.127: U14.99 35.91,41.01 36.13,41.22 36.89,41.22 37.04,41.37 37.04,41.89 R260.2 38,42.97 38.51,43.48 v1(38.51,43.74)
GPIO0: length 2.1
  TOP w0.127: TP21.1 167.66,43.98 U11.17
GPIO_27: length 17.6
  TOP w0.127: R117.1 78.78,66.09 R118.2 80.29,66.18 80.68,66.57 81.97,66.57 v1(82.35,66.19)
  IN1 w0.089: 91.95,65.67 91.95,64.92 v1(92.3,64.57)
  IN1 w0.114: v1(82.35,66.19) 82.71,66.55 84.05,66.55 84.08,66.57 84.16,66.65 85.52,66.65 86.62,67.75 90.07,67.75 90.7,67.12 91.16,67.12 91.54,66.73 91.54,66.08 91.95,65.67
  BOTTOM w0.089: U22.AE39 v1(92.3,64.57)
GPIO_28: length 12.5
  TOP w0.127: R141.1 R142.2 80.67,61.77 81.13,61.77 v1(81.16,61.75)
  IN1 w0.114: v1(89.46,64.57) 88.97,64.08 86.74,64.08 85.46,62.81 82.2,62.81 81.16,61.77 v1(81.16,61.75)
  BOTTOM w0.089: v1(89.46,64.57) U22.AE46
GPIO_43: length 9.6
  BOTTOM w0.089: U22.T53 86.34,68.32 86.21,68.32 86.04,68.44 83.9,68.44 83.31,67.85
  BOTTOM w0.14: R482.1 78.3,67.66 81.32,67.66 81.69,67.28 v1(81.87,67.28) 82.07,67.49 82.94,67.49 83.31,67.85
GPIO_61: length 13.9
  BOTTOM w0.089: U22.N54 85.76,69.51 85.54,69.73 84.57,69.73 84.28,69.44 84.28,69.22 84.05,68.99 84.05,68.92 83.88,68.74
  BOTTOM w0.14: 83.88,68.74 82.85,67.71 81.58,67.71 81.41,67.89 77.78,67.89 76.36,66.47 v1(76.23,66.47) R491.1 75.72,66.1 R490.2
GPIO_62: length 7.2
  BOTTOM w0.089: 83.82,69.01 84.1,69.29 84.1,69.51 84.5,69.9 85.62,69.9 85.82,69.7 86.07,69.7 86.21,69.8 86.34,69.8 86.48,69.7 86.67,69.51 U22.N53
  BOTTOM w0.14: R480.1 81.33,68.11 81.5,68.11 81.68,67.94 82.76,67.94 83.78,68.97 83.82,69.01
GPIO_64: length 8.6
  BOTTOM w0.089: 83.62,69.45 83.74,69.58 83.74,69.65 84.35,70.26 86.02,70.26 86.21,70.13 86.34,70.13 U22.M53
  BOTTOM w0.14: 83.62,69.45 82.97,68.8 79.48,68.8 79.05,68.38 TP53.1
GPIO_65: length 15.9
  BOTTOM w0.089: U22.L54 86.25,70.44 84.28,70.44 83.57,69.73 83.57,69.72 83.52,69.68
  BOTTOM w0.14: R488.2 R489.1 74.07,66.72 TP54.1 74.8,66.51 75.38,66.51 75.85,66.98 76.54,66.98 77.68,68.11 78.04,68.11 78.72,68.8 79.15,68.8 79.38,69.03 82.87,69.03 83.52,69.68
GPIO_66: length 6.5
  BOTTOM w0.089: U22.K53 86.32,70.87 86.07,70.62 84.09,70.62 83.85,70.38
  BOTTOM w0.14: R476.1 R477.2 81.79,69.52 82.21,69.94 82.55,69.94 82.99,70.38 83.85,70.38
GPIO_79: length 5.5
  TOP w0.127: R87.2 91.09,72.64 v1(91.55,72.19)
  IN1 w0.089: v1(91.55,72.19) 92.04,71.69 92.04,70.48 92.49,70.04 v1(92.5,70.04)
  BOTTOM w0.089: U22.M39 92.85,69.7 v1(92.5,70.04)
GPIO_80: length 9.7
  TOP w0.127: v1(93.4,70.8) 93.63,71.03 93.65,71.03 93.91,71.29 93.91,71.64 94.17,71.9 94.17,72.73 94.6,73.16 94.6,76.16 94.27,76.49 v1(94.27,77.14) 94.27,77.65 R62.1
  BOTTOM w0.089: U22.L37 93.84,70.41 v1(93.4,70.8)
GPIO_81: length 14.4
  TOP w0.127: R46.1 90.63,82.73 89.82,81.93 v1(89.82,81.46) 89.82,80.9 90.6,80.12 91.01,80.12 91.77,79.36 91.77,75.57 92.01,75.33 92.01,71.29 v1(92.49,70.82)
  BOTTOM w0.089: U22.J39 92.88,71.12 92.49,70.84 92.49,70.82 v1(92.49,70.82)
GPIO_83: length 7.6
  TOP w0.127: R72.1 R77.2 93.95,76.38 94.27,76.05 94.27,73.2 93.91,72.84 93.91,72 93.47,71.56 v1(93.47,71.47)
  BOTTOM w0.089: U22.J37 v1(93.47,71.47)
GPIO_84: length 13.2
  TOP w0.127: v1(93.43,70.03) 93.43,70.19 93.88,70.63 93.88,70.89 94.14,71.15 94.14,71.16 94.17,71.19 94.17,71.54 94.42,71.79 94.42,72.63 94.93,73.13 94.93,76.35 94.77,76.5 94.77,78.03 93.76,79.04 93.76,79.69 R53.2 R51.1
  BOTTOM w0.089: v1(93.43,70.03) 93.54,70.03 U22.M37
GPIO_85: length 1.4
  TOP w0.127: v1(95.03,69.32) 94.91,69.43 R102.1
  BOTTOM w0.089: v1(95.03,69.32) 95.36,68.99 U22.P33
GPIO_86: length 6.4
  TOP w0.127: R88.1 92.79,74.09 v1(92.46,73.76) 92.95,73.27 92.95,69.85 v1(93.46,69.34)
  BOTTOM w0.089: U22.P37 93.51,69.34 v1(93.46,69.34)
GPIO_87: length 6.8
  TOP w0.127: R70.1 v1(95.41,75.36) 95.21,75.16 95.21,72.39 v1(95,72.19)
  BOTTOM w0.089: U22.L35 94.24,70.72 94.24,72.06 94.37,72.19 v1(95,72.19)
GPIO_89: length 1.7
  TOP w0.127: v1(95.86,70.13) 96.04,70.31 R96.1
  BOTTOM w0.089: v1(95.86,70.13) U22.M33
GPIO_105: length 11.4
  TOP w0.14: R106.2 v1(81.87,68.38)
  IN1 w0.089: v1(90.58,69.9) 90.08,69.9 89.68,70.3 86.32,70.3 85.97,69.96 84.16,69.96 82.97,68.78 82.27,68.78 v1(81.87,68.38)
  BOTTOM w0.089: U22.L46 90.26,69.9 v1(90.58,69.9)
GPIO_140: length 109
  TOP w0.127: Q16.5 v1(56.42,16.56)
  IN1 w0.089: v1(91.6,70.86) 91.09,71.37 91.09,72.31 90.89,72.52 90.41,72.52 87.93,74.99 86.99,74.99 85.07,76.91 84.21,76.91 83.83,77.29 83.83,78.1 83.16,78.76 82,78.76 80.78,77.54 80.78,75.85 80.35,75.43 80.35,72.05 76.49,68.18 71.59,68.18 69.64,66.23 66.29,66.23 64.75,64.7 63.14,64.7 61.36,62.92 61.36,62.03 60.92,61.59 60.56,61.59 59.84,60.87 59.84,60.51 57.5,58.17 57.5,55.91 55.55,53.96 55.55,52.64 49.6,46.7 47.66,46.7 46.63,45.67 46.63,43.85 46.13,43.36 46.13,33.86 45.12,32.85 45.12,32.84 45.03,32.75 45.03,26.12 44.5,25.58 44.5,23.44 46.77,21.17 46.77,20.58 48.51,18.84 49.65,18.84 51.1,17.38 55.59,17.38 v1(56.42,16.56)
  BOTTOM w0.089: v1(91.6,70.86) 91.34,70.86 U22.J43
GPIO_141: length 108.5
  TOP w0.127: Q15.5 v1(52.1,16.56)
  IN1 w0.089: v1(52.1,16.56) 51.59,16.56 50.2,17.96 48.43,17.96 46.58,19.81 46.58,21.09 44.31,23.36 44.31,25.66 44.84,26.2 44.84,35.86 43.85,36.86 43.85,38.53 44.84,39.52 44.84,42.8 46.12,44.09 46.12,48.03 47.07,48.98 51.34,48.98 55.17,52.8 55.17,54.12 57.08,56.03 57.08,59.17 62.98,65.08 64.6,65.08 68.32,68.8 76.3,68.8 79.78,72.28 79.78,75.66 80.21,76.09 80.21,77.78 82.49,80.06 84.36,80.06 85.71,78.7 85.71,77.12 86.28,76.55 88.01,76.55 88.23,76.33 89.19,76.33 89.67,75.85 89.67,74.71 v1(91.56,72.82)
  BOTTOM w0.089: v1(91.56,72.82) 91.13,73.25 U22.D43
GPIO_142: length 105.1
  TOP w0.127: v1(57.82,16.56) 57.82,12.11 v1(56.29,10.59) 56.04,10.34 56.04,8.43 55.55,7.94 Q26.3
  IN1 w0.089: v1(57.82,16.56) 56.8,17.58 51.18,17.58 49.73,19.03 48.59,19.03 46.96,20.66 46.96,21.25 44.69,23.52 44.69,25.5 45.22,26.04 45.22,32.67 45.31,32.76 45.31,32.77 46.32,33.78 46.32,38.04 47.02,38.73 47.02,40.07 52.39,45.44 54.13,45.44 59.15,50.46 59.15,54.11 62.65,57.61 62.65,59.53 64.09,60.97 65.46,60.97 67.42,62.93 69.59,62.93 69.71,62.81 70.78,62.81 71.53,63.57 76.23,63.57 78.21,65.55 78.21,65.99 79.05,66.83 79.7,66.83 79.93,67.07 79.93,67.07 81.97,69.11 82.89,69.11 83.32,69.55 83.33,69.55 83.57,69.78 83.57,69.79 83.92,70.15 85.9,70.15 86.24,70.49 89.08,70.49 90.58,71.98 90.58,72.08 v1(90.58,72.08)
  BOTTOM w0.089: U22.F43 91.03,72.54 90.58,72.08 v1(90.58,72.08)
GPIO_159: length 4.9
  BOTTOM w0.089: R443.2 101.4,77.94 99.33,75.87 99.33,74.85 99.58,74.59 U22.C24
GPIO_163: length 10.5
  TOP w0.127: R65.1 98.84,79.31 v1(98.84,79.3) 98.84,78.92 99.52,78.23 R73.2 99.73,78.12 100.15,77.7 100.15,75.35 99.92,75.13 99.92,73.24 100.07,73.1 100.07,71.9 v1(100.57,71.4)
  BOTTOM w0.089: v1(100.57,71.4) 100.89,71.12 U22.J21
GPIO_164: length 7.1
  TOP w0.127: v1(100.57,69.37) 101.06,69.86 101.82,69.86 102.57,70.62 102.57,73.63 R91.2
  BOTTOM w0.089: U22.M21 100.9,69.7 v1(100.57,69.37)
GPIO_172: length 10.8
  BOTTOM w0.089: U22.C20 101.51,74.55 101.54,74.61 101.58,74.76 101.66,74.88 101.92,75.14
  BOTTOM w0.127: R416.1 105.32,81.96 105.32,80.81 R428.2 105.82,79.55 105.7,79.42 v1(105.32,79.42) 104.97,79.42 103.99,78.45 103.99,77.65 101.92,75.58 101.92,75.14
GPIO_174: length 11.9
  BOTTOM w0.089: U22.C18 102.44,74.61 102.48,74.76 102.56,74.88 102.69,75
  BOTTOM w0.114: 102.69,75 102.69,75.65 103.28,76.25
  BOTTOM w0.127: R418.1 107.35,81.96 107.35,80.81 R430.2 v1(107.86,79.42) 107.17,78.74 105.26,78.74 104.55,78.03 104.55,77.52 103.28,76.25
GPIO_175: length 10.5
  BOTTOM w0.114: U22.A18 102.29,75.64
  BOTTOM w0.127: 102.29,75.64 104.27,77.62 104.27,78.26 105.01,78.99 106.15,78.99 v1(106.59,79.42) 106.84,79.68 R429.2 106.39,80.75 106.39,82.21 106.65,82.46 R417.1
GPIO_PWR: length 59.3
  TOP w0.254: R99.1 90.57,70.53 v1(90.58,70.53) ; R460.2 63.29,65.2 65.18,65.2 65.31,65.33 74.29,65.33 75.38,64.23 v1(75.38,64.18) 76.53,65.33 v1(76.61,65.33) 77.49,65.33 R127.1 77.62,64.95 77.88,64.69 78.52,64.69 78.65,64.57 R132.1
  IN3 w0.254: v1(81.16,73.99) 81.79,73.99 83.48,72.31 89.45,72.31 89.95,71.8 89.95,71.17 v1(90.58,70.53) 90.5,70.53 89.96,70 89.96,68.26 89.44,67.74 87.28,67.74 86.14,66.6 86.14,65.07 86.01,64.95 84.44,64.95 84.09,64.59 78.97,64.59 78.46,65.1 76.28,65.1 75.38,64.21 v1(75.38,64.18)
  BOTTOM w0.254: R463.1 81.66,73.99 v1(81.16,73.99) 80.96,74.19 80.96,74.93 80.69,75.2 R458.1 ; R452.1 79.67,76.88 R447.1 ; R452.1 80.69,77.66 R445.1 R446.1 ; R452.1 80.69,76.1 R458.1 ; R459.1 R458.1
GPJ1: length 3.4
  TOP w0.14: R300.2 40.57,29.89 v1(40.55,29.92) 40.26,29.92 39.4,30.78 U14.77
GPJ3: length 5.7
  TOP w0.127: U14.79 38.37,31.57 40.26,31.57 40.66,31.17 R297.2 41.17,31.42 42.01,31.42 v1(42.32,31.73) 42.7,31.35 R298.2
GPU_CLK#_C: length 4.8
  TOP w0.14: U6.48 121.87,80.52 121.8,80.45 121.8,79.95 121.85,79.9 121.85,76.87 C72.1
GPU_CLK_C: length 4.8
  TOP w0.14: U6.47 121.47,80.52 121.53,80.45 121.53,79.84 121.58,79.79 121.58,76.91 C71.1
GPU_D0#_C: length 2.1
  TOP w0.14: U6.45 120.67,80.52 120.6,80.45 120.6,80.06 120.69,79.97 120.69,79.68 C57.1
GPU_D0_C: length 2.1
  TOP w0.14: C56.1 120.42,79.68 120.42,79.86 120.33,79.95 120.33,80.45 120.27,80.52 U6.44
GPU_D1#_C: length 4.8
  TOP w0.14: U6.42 119.47,80.51 119.4,80.44 119.4,76.91 C70.1
GPU_D1_C: length 4.8
  TOP w0.14: C69.1 119.13,76.87 119.13,80.44 119.07,80.51 U6.41
GPU_D2#_C: length 2.3
  TOP w0.14: C55.1 117.64,79.68 117.64,79.82 118.2,80.38 118.2,80.64 118.27,80.71 U6.39
GPU_D2_C: length 2.3
  TOP w0.14: C54.1 117.37,79.68 117.37,79.93 117.93,80.49 117.93,80.66 117.87,80.72 U6.38
GPU_DDCCLK_Q: length 16.6
  TOP w0.127: R631.1 114.21,82.46 114.01,82.27 114.01,81.62 113.87,81.49 v1(113.87,81.23) 113.87,81.16 114.32,80.72 114.32,80.54 114.46,80.4 R47.2
  BOTTOM w0.127: 113.72,78.91 113.18,79.44 113.18,79.93 113.68,80.43 113.68,81.04 v1(113.87,81.23) 114.08,81.43 114.08,81.84 114.84,82.6 116.32,82.6 116.87,82.04 116.87,80.97 119.18,78.66 119.4,78.66 R628.1 ; 113.72,78.91 R436.2 ; 113.72,78.91 114.59,78.91 114.7,78.8 Q32.3
GPU_DDCCLK_Q_R: length 2.9
  TOP w0.127: R631.2 114.96,83.24 115.48,82.73 v1(115.48,82.35) 115.85,82.72 U6.34
GPU_DDCDATA_Q: length 27.9
  TOP w0.127: R44.2 113.43,80.84 113.43,81.41 113.49,81.48 v1(113.49,81.74) 113.57,81.81 R630.1
  BOTTOM w0.127: R435.2 117.37,79.69 117.51,79.55 117.51,79.13 117.51,79.12 117.51,78.69 117.21,78.39 116.68,78.39 116.43,78.14 116.43,75.93 116.03,75.53 114.03,75.53 113.57,76 113.57,77.68 113.56,77.69 113.56,78.11 113.57,78.12 113.57,78.27 113.26,78.59 113.26,78.99 112.94,79.31 112.94,79.33 112.93,79.34 112.93,80.04 113.43,80.54 113.43,81.67 v1(113.49,81.74) 113.6,81.74 114.71,82.85 116.42,82.85 117.13,82.15 117.13,81.11 119.3,78.94 119.55,78.94 119.66,79.04 R629.1
  BOTTOM w0.14: R435.2 116.74,79.43 116.12,79.43 116,79.55 Q32.6
GPU_DDCDATA_Q_R: length 3.7
  TOP w0.127: R630.2 113.57,83.36 113.95,83.74 114.84,83.74 115.46,83.12 U6.33
GSENSOR_INT: length 153.4
  TOP w0.127: R108.2 88.04,67.07 v1(88.73,66.38) ; Q22.3 104.17,10.72 103.85,11.03 103.85,14.12 103.47,14.5 103.47,16.52 103.85,16.9 103.85,17.64 v1(103.66,17.83) 102.9,18.59 102.9,21.68 v1(102.81,21.77)
  IN1 w0.089: v1(88.73,66.38) 88.4,66.71 87.01,66.71 85.24,64.94 84.52,64.94 83.94,64.36 81.48,64.36 80.64,63.52 80.46,63.52 79,62.06 79,60.59 76.46,58.05 75.71,58.05 73.82,58.05 73.77,57.99 73.4,57.99 72.97,57.56 72.55,57.56 71.75,58.36 66.98,58.36 66.74,58.12 66.74,56.33 66.47,56.06 66.47,53.28 65.82,52.63 65.33,52.63 63.1,50.4 63.1,48.94 55.21,41.05 55.21,37.44 50.72,32.95 49.56,32.95 47.84,31.23 47.84,25.15 48.18,24.81 48.18,21.16 49.09,20.25 83.68,20.25 84.42,19.5 84.42,16.13 84.75,15.8 85.47,15.8 85.87,16.2 85.87,17.09 85.25,17.7 85.25,19.46 85.88,20.1 97.58,20.1 98.24,20.76 101.33,20.76 102.34,21.77 v1(102.81,21.77)
  BOTTOM w0.089: U22.AC46 89.54,65.05 88.73,65.86 88.73,66.38 v1(88.73,66.38)
H_CPU_SVIDCLK: length 63
  TOP w0.14: v1(39.15,66.6) 38.78,66.6 PR29.2 ; PR18.2 v1(48.67,70.03)
  IN3 w0.127: v1(52.46,59.82) 52.46,61.98 49.99,64.44 49.99,67.67 49.94,67.72 49.94,68.76 v1(48.67,70.03) 48.65,70 48.65,69.65 48.27,69.26 47.17,69.26 46.27,68.37 46.27,67.69 44.94,66.36 43.77,66.36 43.54,66.58 39.23,66.58 39.22,66.6 v1(39.15,66.6)
  BOTTOM w0.14: v1(48.67,70.03) 48.67,69.76 PR166.2 ; R462.2 80.19,74.61 R457.2 78.92,73.34 78.92,71.66 76.19,68.93 68.1,68.93 67.67,68.93 66.48,67.75 66.48,67.34 65.22,66.08 64.6,66.08 63.12,64.6 61.25,64.6 55.88,59.22 53.18,59.22 52.58,59.82 v1(52.46,59.82) ; v1(39.15,66.6) 39.52,66.6 PR181.2
H_CPU_SVIDDAT: length 72.3
  TOP w0.14: v1(39.15,65.17) 39.12,65.2 PR33.2 ; v1(48.8,67.11) 49.05,67.11 PR26.2
  IN3 w0.127: v1(51.34,58.67) 51.44,58.77 51.44,61.56 48.98,64.02 48.98,66.57 48.8,66.75 v1(48.8,67.11) 48.78,67.11 48.29,67.59 48.29,68.03 48.08,68.25 47.59,68.25 47.29,67.95 47.29,67.27 46.9,66.88 46.9,66.7 47.29,66.32 47.29,66.17 47.07,65.96 46.93,65.96 46.54,66.34 46.37,66.34 46.19,66.16 46.19,65.98 46.47,65.7 46.47,65.56 46.25,65.34 46.11,65.34 45.83,65.62 45.65,65.62 45.36,65.34 43.35,65.34 43.12,65.57 41.07,65.57 40.96,65.47 40.96,64.46 40.86,64.36 40.56,64.36 40.46,64.46 40.46,65.47 40.35,65.57 40.05,65.57 39.95,65.47 39.95,64.44 39.85,64.34 39.54,64.34 39.44,64.44 39.44,65.07 39.34,65.17 v1(39.15,65.17)
  BOTTOM w0.14: v1(39.15,65.17) 39.15,64.92 39.77,64.29 PR192.2 ; v1(51.34,58.67) 51.09,58.42 51.09,57.96 51.38,57.66 55.79,57.66 61.42,63.3 v1(61.75,63.3) 63.29,63.3 65.03,65.04 65.66,65.04 67.53,66.91 67.53,67.31 68.1,67.89 70.24,67.89 70.38,67.75 70.38,67.12 70.52,66.98 70.8,66.98 70.94,67.12 70.94,67.75 71.08,67.89 71.36,67.89 71.51,67.73 71.51,67.61 71.65,67.47 71.93,67.47 72.07,67.61 72.07,67.76 72.19,67.89 72.47,67.89 72.63,67.73 72.63,67.61 72.77,67.47 73.04,67.47 73.17,67.6 73.17,67.75 73.31,67.89 76.4,67.89 79.78,71.26 R470.2 80.2,71.26 81.25,71.26 81.81,71.66 R471.2 ; v1(48.8,67.11) 49.18,66.72 PR179.2
