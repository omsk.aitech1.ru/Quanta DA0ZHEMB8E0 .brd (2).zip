# Allegro board Quanta ZHE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_BG#1_3: length 9.4
  TOP w0.203: U13.M9 140.38,41.24 141.28,42.14 v1(146.46,42.14) 146.99,42.14 R264.1 R272.2
M_B_BG#1_4: length 4.8
  BOTTOM w0.203: R558.2 R557.1 v1(140.75,31.67) 140.75,33.76 U30.M9
M_B_CKE0: length 90.2
  TOP w0.127: v1(137.04,37.44) 137.04,37.03 137.57,36.5 137.75,36.5 138.41,35.85 138.41,35.58 138.78,35.22 U13.K2 ; v1(137.04,55.23) 137.04,54.71 137.42,54.33 137.71,54.33 138.41,53.63 138.41,53.36 138.78,53 U9.K2
  TOP w0.203: v1(139.58,44.98) 138.83,44.23 R246.2
  IN1 w0.127: v1(106.44,48.21) 106.18,47.95 106.18,47.62 108.13,45.67 109.62,45.67 110.09,46.14 113.46,46.14 118.28,41.32 129.27,41.32 129.4,41.2 129.4,40.61 129.52,40.49 129.78,40.49 129.9,40.61 129.9,41.2 130.03,41.32 131.78,41.32 132.73,42.28 137.32,42.28 137.67,42.62 137.85,42.62 138.56,41.91 138.77,41.91 138.92,42.06 138.92,42.27 138.21,42.98 138.21,43.16 138.39,43.34 138.57,43.34 139.75,42.16 139.94,42.16 140.07,42.3 140.07,42.56 138.93,43.7 138.93,43.88 139.58,44.54 v1(139.58,44.98)
  IN3 w0.178: v1(137.04,37.44) 136.86,37.62 136.86,37.9 137.07,38.1 137.75,38.1 138.03,38.37 138.03,38.98 138.77,39.72 138.77,41.93 138.92,42.09 139.19,42.09 139.35,42.24 139.35,42.47 139.19,42.62 138.44,42.62 138.28,42.78 138.28,43 138.44,43.15 139.19,43.15 139.35,43.31 139.35,43.53 139.19,43.69 138.82,43.69 138.67,43.84 138.67,44.07 138.87,44.27 139.38,44.27 139.58,44.47 139.58,44.98 v1(139.58,44.98) 138.34,46.23 138.34,49.58 139.28,50.52 139.28,51.53 138.03,52.78 138.03,54.05 137.67,54.41 137.47,54.41 137.04,54.83 v1(137.04,55.23)
  BOTTOM w0.089: 104.7,49.94 104.7,52.49 U22.BK13
  BOTTOM w0.127: v1(137.04,55.23) 137.04,55.7 137.19,55.85 137.72,55.85 138.32,56.46 138.32,57.03 138.32,57.24 138.6,57.51 U25.K2 ; v1(137.04,37.44) 137.04,37.77 137.37,38.1 137.74,38.1 138.32,38.68 138.32,39.25 138.32,39.46 138.6,39.73 U30.K2
  BOTTOM w0.203: v1(106.44,48.21) 104.7,49.94
M_B_CLK0: length 89.8
  TOP w0.102: v1(136.43,55.08) 136.38,55.04 136.18,55.04 136.07,55.14 136.07,55.31 136.43,55.66 137.75,55.66 138.44,56.36 138.56,56.36 138.72,56.2 138.86,56.2 138.96,56.3 138.96,56.45 138.78,56.63 U9.K7 ; v1(136.4,37.45) 136.14,37.45 136.07,37.51 136.07,37.76 136.23,37.91 137.94,37.91 138.53,38.49 138.65,38.49 138.81,38.34 138.95,38.34 139.05,38.44 139.05,38.58 138.78,38.85 U13.K7
  TOP w0.203: R219.2 138.59,46.48 138.59,46.06 R229.1 138.56,45.61 138.56,45.21 v1(138.79,44.98)
  IN1 w0.089: v1(103.04,55.11) 103.25,54.9 103.25,54.9 103.64,54.51 103.64,53.39 105.04,51.99 105.04,51.08 105.67,50.44 105.67,50.39 105.7,50.36
  IN1 w0.152: 105.7,50.36 107.84,48.22 107.84,47.98 107.54,47.68 107.54,47.23 107.88,46.89 108.33,46.89 108.63,47.19 108.87,47.19 109.43,46.63 113.67,46.63 118.48,41.82 131.58,41.82 132.53,42.77 137.12,42.77 138.56,44.22 138.56,44.75 v1(138.79,44.98)
  IN3 w0.178: v1(136.43,55.08) 136.2,54.86 136.2,53.89 138.39,51.7 138.39,50.28 137.9,49.79 137.9,46.14 138.56,45.48 138.56,45.21 v1(138.79,44.98) 138.56,44.75 138.56,44.48 137.84,43.76 136.99,43.76 136.68,43.46 136.68,43.03 136.99,42.72 137.74,42.72 138.4,42.06 138.4,39.86 137.73,39.19 136.72,39.19 136.15,38.62 136.15,37.7 v1(136.4,37.45)
  BOTTOM w0.089: v1(103.04,55.11) U22.BF17
  BOTTOM w0.102: U25.K7 139.04,53.51 139.12,53.59 139.12,53.74 138.97,53.9 138.44,53.9 137.81,54.52 136.4,54.52 136.1,54.82 136.1,54.91 136.27,55.08 v1(136.43,55.08) ; U30.K7 139.04,35.73 139.12,35.81 139.12,35.96 138.97,36.12 138.44,36.12 137.86,36.69 136.57,36.69 136.07,37.19 136.07,37.31 136.21,37.45 v1(136.4,37.45)
M_B_CLK0#: length 89.9
  TOP w0.102: v1(135.64,37.45) 135.87,37.68 135.87,37.84 136.14,38.11 137.86,38.11 138.45,38.7 138.45,39.07 138.78,39.4 U13.K8 ; U9.K8 138.78,57.18 138.45,56.85 138.45,56.65 137.66,55.87 136.34,55.87 135.87,55.39 135.87,55.29 v1(135.66,55.08)
  TOP w0.203: v1(138.03,44.98) 138.26,45.21 138.26,45.61 R229.2 138.28,46.11 138.28,46.47 R218.2
  IN1 w0.089: 105.86,50.56 105.81,50.56 105.21,51.15 105.21,52.07 103.82,53.47 103.82,54.58 103.46,54.94 103.46,55.26 103.04,55.68 v1(103.04,55.82)
  IN1 w0.152: 105.86,50.56 108.09,48.33 108.09,47.88 107.79,47.58 107.79,47.34 107.98,47.14 108.22,47.14 108.52,47.44 108.97,47.44 109.53,46.89 113.77,46.89 118.59,42.07 131.47,42.07 132.42,43.03 137.01,43.03 138.31,44.33 138.31,44.7 v1(138.03,44.98)
  IN3 w0.178: v1(135.66,55.08) 135.92,54.83 135.92,53.77 138.11,51.58 138.11,50.39 137.62,49.91 137.62,46.02 138.28,45.36 138.28,45.24 v1(138.03,44.98) 138.28,44.73 138.28,44.6 137.73,44.04 136.87,44.04 136.4,43.57 136.4,42.91 136.87,42.44 137.62,42.44 138.12,41.95 138.12,39.98 137.61,39.47 136.61,39.47 135.87,38.73 135.87,37.68 v1(135.64,37.45)
  BOTTOM w0.089: U22.BD17 v1(103.04,55.82)
  BOTTOM w0.102: v1(135.64,37.45) 135.87,37.22 135.87,37.11 136.49,36.49 137.78,36.49 138.45,35.82 138.45,35.55 138.78,35.22 U30.K8 ; U25.K8 138.78,53 138.45,53.33 138.45,53.6 137.73,54.32 136.31,54.32 135.9,54.74 135.9,54.85 v1(135.66,55.08)
M_B_CS#0: length 89.3
  TOP w0.127: U13.L7 139.38,38.73 139.38,38.33 139.1,38.05 138.84,38.05 138.59,37.79 138.59,37.31 138.66,37.24 v1(138.66,36.96) ; v1(139.08,55.77) 139.48,55.77 139.66,55.95 139.66,56.16 139.53,56.28 139.38,56.28 139.17,56.49 139.17,57.07 139.29,57.19 139.46,57.19 139.58,57.07 U9.L7
  TOP w0.203: R223.2 142.01,47.17 140.61,48.57 v1(140.61,49.06)
  IN3 w0.178: v1(138.66,36.96) 138.66,37.16 138.61,37.21 138.61,37.82 139.12,38.34 139.12,38.81 139.57,39.25 139.57,39.9 140.21,40.55 140.21,43.66 140.65,44.1 140.65,45.71 140.49,45.87 140.49,48.94 v1(140.61,49.06) 140.75,49.19 140.75,49.5 140.52,49.73 140.52,50.09 140.75,50.32 140.75,50.72 140.21,51.26 140.21,52.68 139,53.9 139,54.3 138.58,54.72 138.58,56.03 140.17,57.63 140.4,57.63 140.55,57.47 140.55,57.25 v1(139.08,55.77)
  BOTTOM w0.089: 111.26,52.29 110.63,52.29 109.84,53.08 109.39,53.08 U22.BH2
  BOTTOM w0.127: v1(138.66,36.96) 138.44,36.73 138.44,36.52 138.56,36.4 138.77,36.4 138.97,36.6 139.15,36.6 139.26,36.49 139.26,36.18 139.58,35.86 U30.L7 ; v1(139.08,55.77) 138.56,55.25 138.56,54.79 139.58,53.77 U25.L7
  BOTTOM w0.203: 111.26,52.29 113.92,52.29 114.26,52.63 114.76,52.63 v1(115.09,52.29) 115.4,52.6 115.86,52.6 116.35,52.11 116.83,52.11 117.63,52.91 117.88,52.91 118.07,52.73 118.07,52.47 117.16,51.57 117.16,51.3 117.35,51.11 117.61,51.11 117.85,51.35 118.1,51.35 118.28,51.17 118.28,50.91 118,50.63 118,50.46 120.81,47.65 124.24,47.65 125.67,46.21 127.27,46.21 129.26,48.2 129.26,48.45 128.4,49.3 128.4,49.88 127.99,50.3 127.99,50.59 128.2,50.79 128.49,50.79 129.01,50.26 129.01,49.56 129.74,48.83 129.94,48.83 130.26,49.15 134.88,49.15 135.67,49.93 137.75,49.93 138.03,50.21 138.51,50.21 138.86,49.87 139.53,49.87 139.72,50.06 139.72,50.72 139.89,50.9 140.15,50.9 140.33,50.72 140.33,50.1 140.47,49.96 140.62,49.96 140.93,50.26 141.18,50.26 141.36,50.09 141.36,49.8 v1(140.61,49.06)
M_B_DQ0: length 54.1
  BOTTOM w0.089: U22.BJ26 98.81,52.83 98.81,52.6 98.95,52.46 98.95,52.16 98.71,51.92 98.71,50.79 98.75,50.75 98.79,50.71 98.79,46.2 99.92,45.07
  BOTTOM w0.203: U30.B8 132.12,34.93 131.73,34.54 130.46,34.54 129.95,34.03 129.95,33.7 130.29,33.36 130.29,33.02 130.14,32.88 130.05,32.79 129.71,32.79 129.41,33.1 128.96,33.1 128.37,32.51 118.36,32.51 118.16,32.71 118.16,33.31 117.92,33.55 117.58,33.55 117.34,33.31 117.34,32.71 117.14,32.51 112.23,32.51 110.27,34.48 109.98,34.48 109.32,33.82 108.98,33.82 108.75,34.05 108.75,34.39 109.39,35.04 109.39,35.38 109.15,35.62 108.81,35.62 108.21,35.03 107.8,35.03 99.92,42.91 v1(99.92,43.48) 99.92,45.07
M_B_DQ1: length 53.6
  BOTTOM w0.089: U22.BL26 98.54,52.19 98.54,50.72 98.58,50.68 98.58,45.85 99.41,45.02
  BOTTOM w0.203: U30.C7 132.94,35.73 132.8,35.58 132.8,34.81 132.54,34.55 132.25,34.55 131.99,34.29 131.99,34 131.72,33.73 131.35,33.73 130.92,33.3 130.92,32.93 129.99,32 129.6,32 129.3,32.3 128.88,32.3 128.58,32 112.02,32 111.44,32.59 111.16,32.59 110.57,32 110.12,32 109.91,32.21 109.91,32.54 110.55,33.18 110.55,33.45 110.24,33.75 109.98,33.75 109.28,33.06 109.02,33.06 v1(100.37,41.71) 99.41,42.67 99.41,45.02
M_B_DQ2: length 53.9
  BOTTOM w0.089: 98.9,44.99 98.34,45.55 98.34,48.45 98.33,48.46 98.33,50.66 98.36,50.69 98.36,52.38 98.51,52.53 98.51,52.78 98.39,52.9 98.21,52.9 98.1,53.01 98.1,53.14 U22.BJ27
  BOTTOM w0.203: U30.C8 133.18,34.67 132.76,34.25 132.76,33.82 132.72,33.78 132.72,33.07 132.44,32.79 131.78,32.79 131.63,32.64 131.63,32.43 132,32.07 132,31.73 131.76,31.49 131.42,31.49 131.01,31.91 130.62,31.91 130.2,31.49 109.87,31.49 v1(101.53,39.83) 98.9,42.46 98.9,44.99
M_B_DQ3: length 54.5
  BOTTOM w0.089: U22.BK27 98.23,52.58 98.18,52.53 98.18,50.76 98.08,50.66 98.08,45.31 98.39,44.99
  BOTTOM w0.203: U30.D7 133.59,35.34 133.59,33.93 133.69,33.83 133.69,32.66 132.01,30.99 109.66,30.99 v1(102.64,38.01) 98.39,42.25 98.39,44.99
M_B_DQ4: length 52.7
  BOTTOM w0.089: U22.BJ23 99.84,52.86 99.74,52.71 99.74,52.59 99.84,52.44 99.86,52.43 99.86,51.75 99.87,51.74 99.87,51.07 99.75,50.95 99.75,47.19 101.44,45.5
  BOTTOM w0.203: U30.D3 133.98,38.7 133.91,38.62 133.91,38.14 132.87,37.11 130.81,37.11 127.93,34.22 119.4,34.22 117,36.63 117,38 116.06,38.94 112.08,38.94 110.87,37.72 110.87,37.09 110.63,36.85 110.29,36.85 110.05,37.09 110.05,37.77 109.85,37.97 107.02,37.97 v1(105.72,39.27) 101.44,43.54 101.44,45.5
M_B_DQ5: length 52.9
  BOTTOM w0.089: 101.95,45.58 100.05,47.48 100.05,51.81 100.03,51.82 U22.BK23
  BOTTOM w0.203: 101.95,45.58 101.95,43.75 v1(104.82,40.88) 106.26,39.44 106.81,39.44 107.01,39.24 107.01,38.74 107.25,38.5 107.59,38.5 107.83,38.74 107.83,39.21 108.06,39.44 108.4,39.44 108.64,39.21 108.64,38.72 108.88,38.48 109.21,38.48 109.45,38.72 109.45,39.21 109.69,39.44 110.03,39.44 110.27,39.21 110.27,38.72 110.5,38.48 110.84,38.48 111.08,38.72 111.08,39.24 111.28,39.44 116.27,39.44 117.51,38.21 117.51,36.84 119.61,34.73 127.72,34.73 130.55,37.56 132.57,37.56 133.38,38.38 133.38,38.59 133.59,38.8 133.59,39.32 U30.C2
M_B_DQ6: length 52.4
  BOTTOM w0.089: 102.39,45.54 102.39,45.69 100.39,47.7 100.39,50.93 100.22,51.09 100.22,51.88 100.21,51.9 100.21,52.43 100.24,52.46 100.27,52.52 U22.BJ22
  BOTTOM w0.203: U30.C3 132.79,39.32 132.19,39.32 131.99,39.11 131.99,38.38 131.68,38.07 130.34,38.07 127.54,35.28 123.25,35.28 122.88,35.64 122.88,36.36 122.67,36.57 122.28,36.57 122.07,36.36 122.07,35.59 121.83,35.36 121.49,35.36 121.26,35.59 121.26,36.36 121.04,36.57 120.66,36.57 120.44,36.36 120.44,35.59 120.2,35.36 119.87,35.36 119.63,35.59 119.63,36.74 119.36,37.01 119.08,37.01 118.74,36.66 118.4,36.66 118.16,36.9 118.16,37.24 118.54,37.61 118.54,37.9 116.48,39.95 106.47,39.95 v1(104.04,42.38) 102.39,44.03 102.39,45.54
M_B_DQ7: length 51.7
  BOTTOM w0.089: 102.81,45.41 102.81,45.78 100.72,47.88 100.72,51.05 100.42,51.35 100.42,52.27 U22.BL22
  BOTTOM w0.203: U30.A3 131.23,38.58 130.13,38.58 128.65,37.11 127.66,37.11 127.45,36.9 127.45,36.08 127.22,35.84 126.88,35.84 126.64,36.08 126.64,36.9 126.44,37.11 126.03,37.11 125.83,36.9 125.83,36.08 125.59,35.84 125.25,35.84 125.01,36.08 125.01,36.9 124.81,37.11 124.41,37.11 124.2,36.9 124.2,36.08 123.96,35.84 123.63,35.84 123.39,36.08 123.39,36.9 123.21,37.08 120.07,37.08 116.69,40.46 114.83,40.46 114.62,40.66 114.62,41.44 114.39,41.68 114.05,41.68 113.81,41.44 113.81,40.66 113.61,40.46 113.2,40.46 113,40.66 113,41.54 112.76,41.78 112.42,41.78 112.19,41.54 112.19,40.66 111.98,40.46 106.68,40.46 v1(103.29,43.85) 102.81,44.33 102.81,45.41
M_B_DQ8: length 61.3
  IN1 w0.089: 96.88,52.73 97.75,53.59 97.75,54.19 98.68,55.12 v1(98.67,55.12)
  IN1 w0.127: 96.88,52.73 96.88,44.43 107.1,34.21 108.9,34.21 111.63,31.48 131.31,31.48 132.32,32.48 134.14,32.48 134.65,32.99 134.65,33.86 134.88,34.09 136.13,34.09 137.19,35.15 137.19,35.7 v1(137.58,36.08)
  BOTTOM w0.089: v1(98.67,55.12) 98.47,55.32 U22.BD27
  BOTTOM w0.14: v1(137.58,36.08) 137.93,35.73 U30.J7
M_B_DQ9: length 60.9
  IN1 w0.089: 97.31,52.73 98.21,53.62 98.21,54.26 98.36,54.41 v1(98.67,54.41)
  IN1 w0.127: 97.31,52.73 97.31,44.61 107.28,34.64 109.08,34.64 111.81,31.91 127.57,31.91 127.69,32.04 127.69,32.59 127.84,32.74 128.05,32.74 128.2,32.59 128.2,32.04 128.33,31.91 129.41,31.91 130.23,32.74 130.5,32.74 131.12,32.11 131.34,32.11 131.48,32.26 131.48,32.47 130.92,33.04 130.92,33.27 131.56,33.91 131.74,33.91 132.17,33.47 132.39,33.47 132.53,33.62 132.53,33.83 132.09,34.27 132.09,34.45 132.49,34.85 134.66,34.85 v1(135.18,35.37)
  BOTTOM w0.089: v1(98.67,54.41) 98.67,54.41 98.32,54.76 U22.BF27
  BOTTOM w0.102: U30.F7 135.54,35.73 v1(135.18,35.37)
M_B_DQ10: length 61.1
  IN1 w0.089: v1(98.67,53.7) 98.67,53.69 98.67,53.57 98.2,53.1
  IN1 w0.127: v1(136.78,36.08) 136.28,36.58 135.08,36.58 134.73,36.23 134.73,36.05 134.44,35.76 132.31,35.76 131.17,34.62 130.51,34.62 130.14,34.25 130.14,33.29 129.99,33.14 129.78,33.14 129.63,33.29 129.63,34.23 129.39,34.47 128.93,34.47 128.43,33.98 128.43,33.73 129.26,32.9 129.26,32.69 129.12,32.54 128.91,32.54 128.09,33.35 127.77,33.35 126.77,32.35 111.99,32.35 109.26,35.08 107.46,35.08 98.2,44.34 98.2,53.1
  BOTTOM w0.089: v1(98.67,53.7) 98.67,53.7 98.47,53.9 U22.BH27
  BOTTOM w0.14: U30.H7 137.13,35.73 v1(136.78,36.08)
M_B_DQ11: length 61.6
  IN1 w0.089: v1(98.67,55.83) 98.67,55.83 97.31,54.47 97.31,53.49 96.45,52.63
  IN1 w0.127: 96.45,52.63 96.45,44.26 106.93,33.78 108.72,33.78 111.45,31.05 131.49,31.05 132.5,32.05 134.5,32.05 136.43,33.98 137.03,33.98 v1(137.58,34.53)
  BOTTOM w0.089: v1(98.67,55.83) 98.47,56.03 U22.BC27
  BOTTOM w0.14: v1(137.58,34.53) U30.H8
M_B_DQ12: length 58.8
  IN1 w0.089: 100.45,50.71 100.21,50.95 100.21,52.91 100.46,53.16 100.46,53.58 v1(100.58,53.7)
  IN1 w0.127: v1(137.58,40.13) 137.1,40.61 133.38,40.61 132.08,39.31 131.58,39.31 131.45,39.18 131.45,38.68 131.32,38.56 131.07,38.56 130.95,38.68 130.95,39.18 130.82,39.31 130.61,39.31 125.85,34.55 115.11,34.55 114.62,35.05 114.44,35.05 113.94,34.55 113.73,34.55 113.58,34.7 113.58,34.91 114.08,35.41 114.08,35.59 113.77,35.89 113.27,35.89 113.12,35.74 113.12,34.93 112.99,34.8 112.74,34.8 112.61,34.93 112.61,35.74 112.46,35.89 111.58,35.89 110.18,37.29 108.38,37.29 100.45,45.21 100.45,50.71
  BOTTOM w0.089: U22.BH21 v1(100.58,53.7)
  BOTTOM w0.14: v1(137.58,40.13) U30.H2
M_B_DQ13: length 59.3
  IN1 w0.089: v1(100.58,55.12) 100.19,54.73 100.19,53.27 99.93,53.01 99.93,50.82 100.02,50.73 100.02,50.53
  IN1 w0.127: v1(137.58,38.56) 137.8,38.78 137.8,39.11 137.19,39.72 133.1,39.72 131.29,37.91 131.11,37.91 130.55,38.46 130.37,38.46 130.19,38.28 130.19,38.1 130.75,37.55 130.75,37.37 130.57,37.19 130.39,37.19 129.83,37.74 129.65,37.74 126.03,34.12 112.73,34.12 110,36.85 108.2,36.85 100.02,45.03 100.02,50.53
  BOTTOM w0.089: v1(100.58,55.12) 100.51,55.04 U22.BF23
  BOTTOM w0.14: v1(137.58,38.56) 137.82,38.79 137.84,38.79 U30.J3
M_B_DQ14: length 60
  IN1 w0.089: 99.59,50.55 99.07,51.08 99.07,52.52 100.01,53.47 100.01,54.95 100.12,55.06 100.12,55.49 100.47,55.83 v1(100.58,55.83)
  IN1 w0.127: v1(136.83,38.53) 136.83,39.05 136.63,39.24 135.91,39.24 135.54,38.87 133.83,38.87 132.8,37.84 131.84,37.84 130.51,36.52 130.34,36.52 129.79,37.06 129.58,37.06 129.43,36.92 129.43,36.71 129.98,36.16 129.98,35.99 129.81,35.82 129.6,35.82 129.08,36.35 128.86,36.35 126.21,33.69 112.55,33.69 109.82,36.42 108.02,36.42 99.59,44.85 99.59,50.55
  BOTTOM w0.089: v1(100.58,55.83) 100.51,55.75 U22.BD23
  BOTTOM w0.14: v1(136.83,38.53) 137.18,38.88 U30.H3
M_B_DQ15: length 58.6
  IN1 w0.089: v1(100.58,54.41) 100.67,54.41 100.97,54.11 100.97,53.36 100.39,52.78 100.39,51.28 100.9,50.77
  IN1 w0.127: 100.9,50.77 100.9,45.38 108.56,37.72 110.36,37.72 111.75,36.32 112.63,36.32 112.76,36.45 112.76,36.96 112.91,37.11 113.12,37.11 113.27,36.96 113.27,36.45 113.39,36.32 113.95,36.32 115.29,34.99 125.67,34.99 128.31,37.63 128.31,37.81 127.78,38.34 127.78,38.55 127.93,38.7 128.14,38.7 128.67,38.17 128.85,38.17 129.03,38.35 129.03,38.53 128.47,39.09 128.47,39.3 128.61,39.45 128.82,39.45 129.39,38.89 129.57,38.89 131.04,40.35 132.46,40.35 133.61,41.5 135.03,41.5 v1(135.4,41.13)
  BOTTOM w0.089: v1(100.58,54.41) 100.61,54.41 U22.BF21
  BOTTOM w0.14: U30.G2 135.93,40.18 135.93,40.67 135.66,40.94 135.59,40.94 v1(135.4,41.13)
M_B_DQ16: length 51.4
  TOP w0.14: v1(137.58,32.93) 137.07,33.45 137.07,33.73 136.81,33.98 136.81,34.56 U13.H2
  IN3 w0.178: v1(108.27,43.09) 116.74,34.62 124.88,34.62 125.06,34.44 125.06,33.73 125.26,33.53 125.56,33.53 125.77,33.73 125.77,34.44 125.95,34.62 126.32,34.62 127.52,33.42 129.91,33.42 131.35,31.98 136.63,31.98 v1(137.58,32.93)
  BOTTOM w0.089: 104.45,45.73 104.45,46.1 102.02,48.53 102.02,50.97 101.84,51.15 U22.BK19
  BOTTOM w0.203: 104.45,45.73 107.09,43.09 v1(108.27,43.09)
M_B_DQ17: length 50.7
  TOP w0.14: U13.J3 137.98,35.69 v1(137.62,35.33)
  IN3 w0.178: v1(109.58,43.12) 109.58,42.54 117.02,35.1 126.52,35.1 127.69,33.93 130.2,33.93 131.67,32.46 135.41,32.46 136.15,33.2 136.15,33.86 v1(137.62,35.33)
  BOTTOM w0.089: 104.05,45.71 104.05,46.02 101.76,48.31 101.76,50.85 101.66,50.95 101.66,52.43 101.52,52.61 U22.BJ20
  BOTTOM w0.203: v1(109.58,43.12) 109.58,43.03 108.95,42.39 107.05,42.39 104.05,45.4 104.05,45.71
M_B_DQ18: length 52.4
  TOP w0.14: v1(135.97,34.52) U13.G2
  IN3 w0.178: v1(135.97,34.52) 135.67,34.22 135.67,33.48 135.31,33.12 134.09,33.12 133.66,33.55 133.66,33.78 131.85,35.58 130.06,35.58 129.85,35.38 129.85,34.72 129.68,34.54 129.32,34.54 129.14,34.72 129.14,35.38 128.97,35.56 128.61,35.56 128.43,35.38 128.43,34.72 128.25,34.54 127.9,34.54 127.72,34.72 127.72,35.38 127.52,35.58 117.35,35.58 110.85,42.08 v1(110.85,43.12)
  BOTTOM w0.089: U22.BL20 101.43,52.29 101.43,48.13 103.66,45.9 103.66,45.59
  BOTTOM w0.203: v1(110.85,43.12) 110.85,43.05 109.38,41.58 107.14,41.58 103.66,45.06 103.66,45.59
M_B_DQ19: length 52.1
  TOP w0.14: v1(136.77,35.37) 137.14,35.73 U13.H3
  IN3 w0.102: 134.8,34.86 134.89,34.95 136.35,34.95 v1(136.77,35.37)
  IN3 w0.178: v1(111.54,43.13) 111.34,42.93 111.34,42.4 117.67,36.07 132.12,36.07 133.32,34.86 134.8,34.86
  BOTTOM w0.089: 103.23,45.44 103.23,45.9 101.12,48 101.12,51.03 101.23,51.14 101.23,52.08 101.11,52.2 101.11,52.38 101.13,52.45 101.18,52.51 101.21,52.6 101.21,52.72 101.17,52.79 101.15,52.82 U22.BJ21
  BOTTOM w0.203: v1(111.54,43.13) 111.54,43 111.09,42.55 111.09,42.27 111.54,41.82 111.54,41.5 111.28,41.25 110.96,41.25 110.52,41.69 110.23,41.69 109.61,41.07 106.93,41.07 103.23,44.77 103.23,45.44
M_B_DQ20: length 49.6
  TOP w0.127: v1(135.11,38.43) 135.58,38.9 U13.F7
  IN3 w0.178: v1(135.11,38.43) 135.06,38.43 134.58,37.95 131.8,37.95 131.63,38.12 120.2,38.12 119.84,38.48 119.56,38.48 118.78,37.69 118.47,37.69 118.25,37.91 118.25,38.22 119.05,39.02 119.05,39.27 118.8,39.52 118.55,39.52 117.78,38.76 117.48,38.76 117.28,38.96 117.28,39.26 118.04,40.03 118.04,40.28 117.79,40.53 117.54,40.53 116.94,39.93 116.49,39.93 114.66,41.76 114.66,42.11 112.62,44.16 112.37,44.16 112,43.79 111.74,43.79 111.49,44.04 111.49,44.29 111.86,44.66 111.86,44.91 111.62,45.15 v1(110.92,45.15)
  BOTTOM w0.089: 105.9,46.44 105.9,46.68 102.9,49.68 102.9,51.23 103.1,51.43 103.1,51.95 102.91,52.14 102.91,52.43 102.94,52.45 103.02,52.57 103.02,52.68 102.99,52.76 102.94,52.85 102.74,53.04 U22.BJ17
  BOTTOM w0.203: 105.9,46.44 107.69,44.65 110.57,44.65 110.92,44.99 v1(110.92,45.15)
M_B_DQ21: length 50.3
  TOP w0.14: v1(136.28,41.73) 136.73,41.28 136.73,40.39 137.18,39.94 U13.H8
  IN3 w0.178: v1(136.28,41.73) 135.86,41.31 135.86,40.85 135.62,40.61 134.2,40.61 133.29,39.7 132.11,39.7 131.5,39.09 120.69,39.09 116.71,43.07 116.3,43.07 115.84,42.6 115.59,42.6 115.34,42.86 115.34,43.11 115.85,43.62 115.85,43.92 115.65,44.13 115.35,44.13 114.83,43.61 114.58,43.61 114.33,43.86 114.33,44.11 114.85,44.63 114.85,44.93 114.64,45.13 114.35,45.13 113.83,44.62 113.58,44.62 113.33,44.87 113.33,45.12 113.84,45.64 113.84,45.93 113.63,46.14 113.34,46.14 112.82,45.62 112.57,45.62 112,46.19 v1(109.44,46.19)
  BOTTOM w0.089: U22.BJ16 103.33,52.61 103.46,52.43 103.46,50.8 103.69,50.57 103.69,49.86 106.79,46.76 107.02,46.76
  BOTTOM w0.203: 107.02,46.76 108.08,45.69 109.1,45.69 109.44,46.04 v1(109.44,46.19)
M_B_DQ22: length 49.6
  TOP w0.14: U13.H7 136.76,39.35 136.76,39.9 136.51,40.16 136.23,40.16 135.93,40.45 135.93,40.89 135.86,40.95 135.86,41.31 v1(135.41,41.76)
  IN3 w0.178: v1(108.15,46.37) 108.49,46.71 108.87,46.71 109.05,46.89 109.05,47.69 109.26,47.9 109.55,47.9 109.76,47.69 109.76,46.89 109.94,46.71 110.29,46.71 110.47,46.89 110.47,47.77 110.68,47.98 110.97,47.98 111.18,47.77 111.18,46.89 111.36,46.71 111.71,46.71 111.89,46.89 111.89,47.77 112.1,47.98 112.4,47.98 112.6,47.77 112.6,46.89 112.78,46.71 113.75,46.71 120.89,39.57 128.65,39.57 129.26,40.18 132.46,40.18 134.05,41.76 v1(135.41,41.76)
  BOTTOM w0.089: 107.32,47.19 106.81,47.19 104.12,49.88 104.12,50.6 103.64,51.08 U22.BK15
  BOTTOM w0.203: v1(108.15,46.37) 107.32,47.19
M_B_DQ23: length 49.6
  TOP w0.127: v1(137.67,41.76) 138.44,40.99 138.44,39.62 137.98,39.17 U13.J7
  IN3 w0.102: 134.16,39.7 135.77,39.7 136.71,40.64 136.71,41.48 136.98,41.76 v1(137.67,41.76)
  IN3 w0.178: 134.16,39.7 133.68,39.22 132.31,39.22 131.7,38.6 120.41,38.6 117.71,41.29 117.46,41.29 116.96,40.8 116.71,40.8 116.46,41.05 116.46,41.3 116.98,41.82 116.98,42.11 116.77,42.32 116.48,42.32 115.96,41.8 115.71,41.8 111.82,45.69 109.91,45.69 109.62,45.4 v1(109.62,45.17)
  BOTTOM w0.089: 106.7,46.35 103.21,49.85 103.21,51.14 103.29,51.22 103.29,52.24 U22.BL16
  BOTTOM w0.203: 106.7,46.35 107.88,45.17 v1(109.62,45.17)
M_B_DQ24: length 52.5
  TOP w0.14: U13.C3 133.18,36.4 132.84,36.73 132.19,36.73 131.75,36.28
  TOP w0.203: 131.75,36.28 126.2,36.28 124.99,37.5 v1(124.99,37.65)
  IN1 w0.089: 101.67,49.82 101.67,52.73 101.5,52.89 101.5,54.33 101.36,54.48 101.36,56.17 100.58,56.95 v1(100.58,57.25)
  IN1 w0.127: v1(124.99,37.65) 123.73,36.38 115.87,36.38 112.4,39.85 110.67,39.85 110.5,40.03 110.5,40.51 110.37,40.64 110.11,40.64 109.98,40.51 109.98,39.95 109.86,39.83 109.6,39.83 109.48,39.95 109.48,40.51 109.35,40.64 109.1,40.64 108.97,40.51 108.97,39.95 108.84,39.83 108.59,39.83 108.46,39.95 108.46,40.51 108.33,40.64 107.61,40.64 102.32,45.93 102.32,49.17 101.67,49.82
  BOTTOM w0.089: U22.BA21 100.61,57.25 v1(100.58,57.25)
M_B_DQ25: length 52.8
  TOP w0.14: 131.75,36.79 132.01,37.06 132.98,37.06 133.53,36.5 133.53,35.28 U13.C2
  TOP w0.203: 131.75,36.79 126.84,36.79 126.26,37.37 v1(126.26,37.65)
  IN1 w0.089: 101.46,49.57 101.46,52.63 101.33,52.77 101.33,54.26 101.18,54.4 101.18,56.1 100.61,56.67 100.46,56.67 100.13,57 100.13,57.46 v1(99.63,57.96)
  IN1 w0.127: v1(126.26,37.65) 124.56,35.95 115.69,35.95 112.25,39.39 108.25,39.39 101.89,45.75 101.89,49.15 101.46,49.57
  BOTTOM w0.089: U22.AY23 v1(99.63,57.96)
M_B_DQ26: length 54.4
  TOP w0.14: 131.77,37.3 131.91,37.44 133.1,37.44 133.84,36.7 133.84,35.87 U13.D3
  TOP w0.203: v1(127.53,37.65) 127.88,37.3 131.77,37.3
  IN1 w0.089: v1(99.63,57.25) 99.63,57.25 100.39,56.49 100.54,56.49 101,56.02 101,54.33 101.15,54.19 101.15,52.68 101.26,52.56 101.26,49.31
  IN1 w0.127: v1(127.53,37.65) 125.4,35.52 115.51,35.52 112.07,38.96 110.57,38.96 110.44,38.83 110.44,38.38 110.31,38.25 110.06,38.25 109.93,38.38 109.93,38.83 109.8,38.96 109.55,38.96 109.42,38.83 109.42,38.38 109.3,38.25 109.04,38.25 108.92,38.38 108.92,38.83 108.79,38.96 108.07,38.96 101.45,45.58 101.45,49.12 101.26,49.31
  BOTTOM w0.089: U22.BA23 v1(99.63,57.25)
M_B_DQ27: length 50.8
  TOP w0.14: 133.03,42.21 133.61,41.63 133.61,39.3 133.97,38.93 U13.D7
  TOP w0.203: 133.03,42.21 122.56,42.21 120.85,40.5 v1(120.85,40.28)
  IN1 w0.089: 104.68,50.65 104.68,51.72 103.18,53.22 103.18,53.64 102.75,54.07 102.75,54.85 102.62,54.98 102.62,56.82 v1(103.04,57.24)
  IN1 w0.127: v1(120.85,40.28) 118.56,40.28 114.41,44.44 113.39,44.44 113.26,44.56 113.26,45.45 113.11,45.6 112.91,45.6 112.75,45.45 112.75,44.56 112.63,44.44 112.37,44.44 112.25,44.56 112.25,45.45 112.09,45.6 111.89,45.6 111.74,45.45 111.74,44.56 111.61,44.44 108.61,44.44 105.48,47.56 105.48,49.85 104.68,50.65
  BOTTOM w0.089: U22.BA17 v1(103.04,57.24)
M_B_DQ28: length 53.2
  TOP w0.203: v1(124.31,37.62) 124.31,37.21 125.79,35.73 U13.A3
  IN1 w0.089: v1(100.58,57.96) 101.07,57.47 101.07,56.78 101.54,56.31 101.54,54.55 101.68,54.41 101.68,53.01 101.89,52.8 101.89,52.03 101.89,51.75 101.89,49.98
  IN1 w0.127: 101.89,49.98 102.75,49.12 102.75,46.11 107.79,41.07 110.65,41.07 111.32,40.4 112.46,40.4 116.05,36.82 116.38,36.82 116.51,36.94 116.51,37.43 116.66,37.58 116.87,37.58 117.02,37.43 117.02,36.96 117.16,36.82 117.38,36.82 117.52,36.96 117.52,37.43 117.67,37.58 117.88,37.58 118.03,37.43 118.03,36.96 118.18,36.82 118.39,36.82 118.54,36.96 118.54,37.43 118.69,37.58 118.9,37.58 119.05,37.43 119.05,36.96 119.2,36.82 119.41,36.82 119.56,36.96 119.56,37.43 119.7,37.58 119.92,37.58 120.06,37.43 120.06,36.96 120.21,36.82 120.42,36.82 120.57,36.96 120.57,37.43 120.72,37.58 120.93,37.58 121.08,37.43 121.08,36.94 121.21,36.82 123.5,36.82 v1(124.31,37.62)
  BOTTOM w0.089: U22.AY21 100.61,57.96 v1(100.58,57.96)
M_B_DQ29: length 50.7
  TOP w0.14: 132.11,41.55 132.82,40.84 132.82,40.39 133.18,40.04 U13.C8
  TOP w0.203: 132.11,41.55 123.22,41.55 122.16,40.49 v1(122.16,40.26)
  IN1 w0.089: 104.48,50.41 104.48,51.59 102.92,53.14 102.92,53.57 102.57,53.92 102.57,54.78 102.44,54.91 102.44,56.89 102.56,57.01 102.56,57.47 v1(103.04,57.95)
  IN1 w0.127: v1(122.16,40.26) 121.69,39.79 118.45,39.79 117.9,40.33 117.72,40.33 117.46,40.06 117.25,40.06 117.1,40.21 117.1,40.42 117.35,40.67 117.35,40.88 117.2,41.03 116.99,41.03 116.74,40.78 116.53,40.78 116.38,40.93 116.38,41.14 116.63,41.39 116.63,41.6 116.48,41.75 116.27,41.75 116.02,41.5 115.81,41.5 115.66,41.65 115.66,41.86 115.91,42.11 115.91,42.32 115.76,42.47 115.55,42.47 115.3,42.22 115.09,42.22 114.94,42.37 114.94,42.58 115.19,42.83 115.19,43.04 115.04,43.19 114.83,43.19 114.58,42.94 114.37,42.94 114.22,43.09 114.22,43.3 114.49,43.56 114.49,43.74 114.23,44 108.43,44 105.05,47.38 105.05,49.85 104.48,50.41
  BOTTOM w0.089: U22.AY17 v1(103.04,57.95)
M_B_DQ30: length 51.8
  TOP w0.14: U13.B8 131.93,39.28 130.52,39.28
  TOP w0.203: 130.52,39.28 129.55,40.26 v1(124.7,40.26)
  IN1 w0.089: 103.24,50.77 103.24,52.12 102.52,52.83 102.52,53.29 102.22,53.59 102.22,54.63 102.09,54.76 102.09,56.58 101.64,57.03 101.64,57.51 v1(102.09,57.96)
  IN1 w0.127: 103.24,50.77 104.16,49.85 104.16,46.61 108.35,42.42 111.21,42.42 111.88,41.74 113.02,41.74 115.84,38.92 123.52,38.92 123.65,39.05 123.65,39.6 123.8,39.75 124.01,39.75 124.16,39.6 124.16,39.12 124.35,38.92 126.73,38.92 126.91,39.1 126.91,39.35 126.73,39.52 124.87,39.52 124.7,39.69 v1(124.7,40.26)
  BOTTOM w0.089: U22.AY19 v1(102.09,57.96)
M_B_DQ31: length 51.2
  TOP w0.14: 131.07,40.41 131.32,40.16 132.49,40.16 132.82,39.83 132.82,39.29 U13.C7
  TOP w0.203: 131.07,40.41 130.56,40.92 124.03,40.92 123.43,40.31 v1(123.43,40.26)
  IN1 w0.089: v1(102.09,57.25) 102.27,57.08 102.27,54.83 102.39,54.71 102.39,53.74 102.74,53.39 102.74,52.93 103.46,52.21 103.46,50.95
  IN1 w0.127: v1(123.43,40.26) 122.53,39.36 117.67,39.36 117.4,39.63 116.97,39.63 116.69,39.36 116.48,39.36 116.33,39.5 116.33,39.71 116.61,39.99 116.61,40.2 116.46,40.35 116.25,40.35 115.74,39.84 115.53,39.84 115.38,39.99 115.38,40.2 115.89,40.71 115.89,40.92 115.74,41.07 115.53,41.07 115.02,40.56 114.81,40.56 114.66,40.71 114.66,40.92 115.17,41.43 115.17,41.64 115.02,41.79 114.81,41.79 114.3,41.28 114.09,41.28 113.95,41.43 113.95,41.64 114.41,42.11 114.41,42.29 113.13,43.57 108.25,43.57 104.59,47.23 104.59,49.82 103.46,50.95
  BOTTOM w0.089: U22.BA19 v1(102.09,57.25)
M_B_DQ32: length 46.5
  IN3 w0.089: 134.07,52.74 134.78,52.74 v1(135.18,53.14) ; v1(106.1,58.32) 106.33,58.08 106.33,57.07 106.46,56.95 108.34,56.95 108.66,56.62 108.66,55.25 109.56,54.35 110.78,54.35
  IN3 w0.178: 134.07,52.74 133.55,52.21 133.55,51.12 132.82,50.39 131.84,50.39 129.37,47.93 129.37,46.97 127.72,45.31 124.46,45.31 124.28,45.49 124.28,46.31 124.08,46.51 123.78,46.51 123.57,46.31 123.57,45.49 123.39,45.31 123.04,45.31 122.86,45.49 122.86,46.37 122.65,46.58 122.36,46.58 122.15,46.37 122.15,45.49 121.97,45.31 121.72,45.31 113.08,53.95 111.18,53.95 110.78,54.35
  BOTTOM w0.089: U22.AR8 106.1,59.38 v1(106.1,58.32)
  BOTTOM w0.102: U25.F7 135.41,53.34 135.38,53.34 v1(135.18,53.14)
M_B_DQ33: length 47.5
  IN3 w0.089: v1(103.97,60.83) 104.83,59.97 108.62,59.97 109.48,59.1 109.48,57.55 110.31,56.73 111.28,56.73
  IN3 w0.178: 111.28,56.73 111.68,56.73 112.29,56.12 115.47,56.12 115.65,55.94 115.65,55.38 115.86,55.17 116.15,55.17 116.36,55.38 116.36,55.91 116.57,56.12 116.87,56.12 117.07,55.91 117.07,55.4 117.28,55.19 117.58,55.19 117.78,55.4 117.78,55.94 117.96,56.12 119.17,56.12 120.5,57.45 125.2,57.45 126.42,56.23 127.89,56.23 128.07,56.41 128.07,57.12 128.27,57.33 128.57,57.33 128.78,57.12 128.78,56.41 128.95,56.23 129.31,56.23 129.49,56.41 129.49,57.14 129.7,57.35 129.99,57.35 130.2,57.14 130.2,56.41 130.38,56.23 131.18,56.23 133.84,58.9 136.15,58.9 v1(136.78,59.54)
  BOTTOM w0.089: U22.AN15 v1(103.97,60.83)
  BOTTOM w0.14: U25.G2 136,57.89 136,58.75 v1(136.78,59.54)
M_B_DQ34: length 48
  IN3 w0.089: 111.28,55.63 110.41,55.63 109.89,56.16 109.89,56.72 109.2,57.4 109.2,58.94 108.4,59.74 104.34,59.74 v1(103.26,60.83)
  IN3 w0.178: v1(137.58,57.91) 137.07,58.42 134.04,58.42 131.38,55.75 130.56,55.75 130.26,55.44 130.26,54.56 130.05,54.35 129.75,54.35 129.54,54.56 129.54,55.57 129.37,55.75 129.01,55.75 128.83,55.57 128.83,54.56 128.62,54.35 128.33,54.35 128.12,54.56 128.12,55.47 127.84,55.75 126.22,55.75 125,56.97 120.7,56.97 118.42,54.68 117.4,54.68 117.22,54.51 117.22,53.93 117.01,53.72 116.72,53.72 116.51,53.93 116.51,54.51 116.33,54.68 115.53,54.68 114.58,55.63 111.28,55.63
  BOTTOM w0.089: U22.AN17 v1(103.26,60.83)
  BOTTOM w0.102: v1(137.58,57.91) U25.H2
M_B_DQ35: length 49.2
  IN3 w0.089: 110.34,54 109.02,54 107.02,56.01 106.56,56.01 106.41,56.16 105.92,56.16 105.68,56.39 105.68,57.06 105.87,57.25 105.87,57.84 v1(105.39,58.32)
  IN3 w0.178: 110.34,54 110.87,53.47 112.63,53.47 113.11,52.98 113.11,52.7 112.92,52.5 112.92,52.21 113.12,52.01 113.41,52.01 113.72,52.32 114.01,52.32 114.21,52.12 114.21,51.83 113.86,51.48 113.86,51.19 114.07,50.98 114.36,50.98 114.72,51.34 115.01,51.34 115.22,51.13 115.22,50.83 114.87,50.48 114.87,50.18 115.08,49.98 115.37,49.98 115.72,50.33 116.02,50.33 116.23,50.12 116.23,49.83 115.87,49.47 115.87,49.18 116.08,48.97 116.38,48.97 116.71,49.31 116.96,49.31 121.44,44.83 127.94,44.83 129.86,46.75 129.86,47.73 132.04,49.91 135.06,49.91 v1(135.78,50.64)
  BOTTOM w0.089: U22.AU12 105.39,58.39 v1(105.39,58.32)
  BOTTOM w0.127: U25.H7 136.72,53.05 136.72,51.77 136.23,51.27 136.23,51.08 v1(135.78,50.64)
M_B_DQ36: length 45.1
  IN3 w0.089: v1(105.39,60.83) 105.79,60.43 109.02,60.43 110.07,59.38 110.07,57.93 110.4,57.61 111.28,57.61
  IN3 w0.178: 111.28,57.61 112.33,57.61 112.85,57.08 118.77,57.08 120.1,58.42 131.02,58.42 133.28,60.68 134.45,60.68 134.63,60.86 134.63,61.75 134.81,61.92 135.16,61.92 135.34,61.75 135.34,60.86 135.52,60.68 137.93,60.68 138.61,59.99 138.61,56.89 138.02,56.3 v1(137.52,56.3)
  BOTTOM w0.089: U22.AN12 v1(105.39,60.83)
  BOTTOM w0.102: U25.J3 137.73,56.46 137.68,56.46 v1(137.52,56.3)
M_B_DQ37: length 45.4
  IN3 w0.089: 111.28,57.12 110.37,57.12 109.79,57.71 109.79,59.23 108.82,60.2 105.31,60.2 v1(104.68,60.83)
  IN3 w0.102: 137.8,56.7 137.17,56.7 v1(136.78,56.31)
  IN3 w0.178: 137.8,56.7 138.13,57.03 138.13,59.61 137.65,60.09 133.53,60.09 132.57,59.13 132.57,58.52 131.31,57.26 130.76,57.26 130.09,57.94 127.61,57.94 127.41,57.73 127.41,57.2 127.2,57 126.9,57 126.69,57.2 126.69,57.73 126.49,57.94 120.3,57.94 118.97,56.6 112.64,56.6 112.12,57.12 111.28,57.12
  BOTTOM w0.089: U22.AN13 v1(104.68,60.83)
  BOTTOM w0.102: v1(136.78,56.31) U25.H3
M_B_DQ38: length 49.9
  IN3 w0.089: v1(104.68,58.29) 104.68,57.65 105.43,56.9 105.43,53.43 105.85,53 106.08,53
  IN3 w0.178: 106.08,53 109.82,53 110.5,52.32 112.05,52.32 116.36,48 116.59,48 116.94,48.35 117.23,48.35 117.44,48.14 117.44,47.85 117.13,47.53 117.13,47.24 117.34,47.03 117.63,47.03 117.95,47.35 118.24,47.35 118.44,47.14 118.44,46.86 118.12,46.54 118.12,46.25 118.35,46.02 118.64,46.02 118.99,46.38 119.21,46.38 119.79,45.79 119.79,45.06 120.5,44.35 128.14,44.35 130.34,46.55 130.34,47.53 132.24,49.43 135.41,49.43 v1(136.57,50.58)
  BOTTOM w0.089: v1(104.68,58.29) 104.68,58.39 U22.AU13
  BOTTOM w0.127: U25.H8 137.18,52.47 137.52,52.13 137.52,51.67 137.2,51.35 137.2,51.06 136.73,50.58 v1(136.57,50.58)
M_B_DQ39: length 49.7
  IN3 w0.089: 105.06,52.88 104.43,53.52 104.43,57.45 103.97,57.91 v1(103.97,58.39)
  IN3 w0.178: v1(137.33,50.58) 135.69,48.94 132.44,48.94 130.82,47.33 130.82,46.35 128.24,43.76 119.92,43.76 111.85,51.84 109.48,51.84 108.95,52.37 105.57,52.37 105.06,52.88
  BOTTOM w0.089: v1(103.97,58.39) U22.AU15
  BOTTOM w0.127: U25.J7 137.98,53.29 138.32,52.94 138.32,51.28 137.62,50.58 v1(137.33,50.58)
M_B_DQ40: length 32.9
  BOTTOM w0.089: U22.AY3 109.16,57.15 109.4,57.15 109.49,57.07 110.06,57.07 110.34,57.35 112.3,57.35 112.45,57.2
  BOTTOM w0.203: U25.A3 131.1,56.71 130.51,57.3 130.51,59.34 131.37,60.19 131.37,60.53 131.13,60.77 130.79,60.77 130.41,60.4 130.07,60.4 129.82,60.64 129.82,60.98 130.16,61.32 130.16,61.66 129.92,61.9 129.58,61.9 128.73,61.05 121.5,61.05 120.88,61.67 117.15,61.67 116.26,60.78 116.26,59.55 114.86,58.15 v1(114.86,57.92) 114.14,57.2 112.45,57.2
M_B_DQ41: length 32.5
  BOTTOM w0.089: 111.26,54.13 110.93,54.13 109.82,55.24 109.54,55.24 109.38,55.4 109.26,55.4 109.18,55.32 109.05,55.32 108.97,55.4 U22.BD3
  BOTTOM w0.203: 111.26,54.13 111.65,53.73 116.87,53.73 v1(118.07,54.93) 120.63,57.49 124.69,57.49 125.24,56.95 125.86,56.95 126.33,57.42 126.69,57.42 126.93,57.18 126.93,56.87 126.42,56.36 126.42,56.1 129.74,52.79 129.74,52.26 130.94,51.05 132.34,51.05 132.52,51.23 132.52,51.48 132.76,51.73 132.76,52.03 133.18,52.45 U25.C8
M_B_DQ42: length 32.3
  BOTTOM w0.089: U22.BD1 109.9,55.54 110.85,54.58 111.49,54.58
  BOTTOM w0.203: U25.B8 132.52,52.57 132.52,52.42 132.39,52.29 131.23,52.29 131.13,52.2 130.51,52.2 130.23,52.47 130.23,53.01 127.19,56.06 127.19,56.41 127.44,56.66 127.44,57.39 126.83,58 126.2,58 125.75,57.55 125.35,57.55 124.9,58 120.24,58 119.92,58.32 119.54,58.32 119.39,58.16 119.39,57.76 119.64,57.5 119.64,57.22 v1(119.03,56.61) 117.55,55.13 117.34,55.13 117.12,55.35 116.68,55.35 116.47,55.14 116.47,54.85 116.76,54.55 116.76,54.34 116.62,54.2 113.8,54.2 113.44,54.56 112.78,54.56 112.43,54.2 111.87,54.2 111.49,54.58
M_B_DQ43: length 32.9
  BOTTOM w0.089: U22.BC3 108.66,56.12 108.74,56.2 108.89,56.2 109,56.09 109,55.86 109.19,55.68 109.38,55.68 109.51,55.81 109.98,55.81 110.58,55.21 110.73,55.06 114.57,55.06 114.79,54.84
  BOTTOM w0.102: 131.39,53.04 132.4,53.04 132.62,53.26 132.85,53.26 133.07,53.04 133.38,53.04 133.64,53.3 133.64,53.41 133.54,53.51 U25.C7
  BOTTOM w0.203: 114.79,54.84 115.37,54.84 116.44,55.9 117.61,55.9 118.42,56.72 118.42,58.12 119.38,59.08 119.88,59.08 120.44,58.51 v1(125.51,58.51) 127.07,58.51 127.95,57.63 127.95,56.02 130.6,53.36 131.08,53.36 131.39,53.04
M_B_DQ44: length 31.8
  BOTTOM w0.089: 112.62,57.61 112.53,57.71 110.37,57.71 110,57.34 U22.AY1
  BOTTOM w0.203: U25.C2 132.92,57.51 132.52,57.91 131.44,57.91 131.2,58.15 131.2,59.08 131.95,59.83 131.95,60.67 130.14,62.48 129.42,62.48 128.49,61.56 121.71,61.56 121.09,62.18 116.91,62.18 v1(115.87,61.14) 115.75,61.02 115.75,59.76 114.33,58.34 114.33,58.09 113.86,57.61 112.62,57.61
M_B_DQ45: length 32.9
  BOTTOM w0.089: U22.BA3 108.66,56.78 108.74,56.69 109.07,56.69 109.2,56.56 109.37,56.56 109.51,56.71 110.14,56.71 111.75,56.71 112.12,56.34
  BOTTOM w0.203: 112.12,56.34 114.71,56.34 v1(114.93,56.55) 115.77,57.39 115.77,57.62 118.75,60.6 120.51,60.6 121.08,60.03 127.7,60.03 129.47,58.26 129.47,56.65 130.85,55.27 131.91,55.27 132.1,55.08 132.1,54.71 132.33,54.48 132.72,54.48 132.91,54.67 132.91,55.01 132.91,55.22 134.09,56.4 134.09,56.6 U25.D3
M_B_DQ46: length 32.3
  BOTTOM w0.089: U22.BA2 110.21,56.89 110.34,57.02 112,57.02 112.27,56.74
  BOTTOM w0.203: 112.27,56.74 114.4,56.74 115.31,57.66 115.31,57.89 v1(116.38,58.96) 117.23,59.8 117.23,60.09 116.98,60.34 116.98,60.68 117.22,60.91 117.55,60.91 117.8,60.66 118.09,60.66 118.54,61.11 120.72,61.11 121.29,60.54 127.91,60.54 128.37,60.08 128.66,60.08 129.02,60.44 129.3,60.44 129.59,60.15 129.59,59.86 129.24,59.51 129.24,59.22 130,58.45 130,56.89 131.08,55.81 132.89,55.81 133.18,56.11 U25.C3
M_B_DQ47: length 32.3
  BOTTOM w0.089: 112.64,53.22 111.48,53.22 109.76,54.94 109.43,54.94 U22.BE2
  BOTTOM w0.102: U25.D7 133.98,53.21 133.56,52.79 133.56,52.12
  BOTTOM w0.203: 133.56,52.12 133.56,51.15 133.03,50.62 130.74,50.62 129.22,52.14 129.22,52.59 125.39,56.42 125.04,56.42 124.48,56.98 120.84,56.98 117.08,53.22 v1(116.34,53.22) 112.64,53.22
M_B_DQ48: length 36.7
  TOP w0.14: v1(137.58,57.11) U9.J7
  IN1 w0.127: v1(108.24,59.34) 108.44,59.55 115.47,59.55 117.87,61.95 126.77,61.95 127.61,61.11 132.49,61.11 133.24,60.36 133.65,60.36 133.77,60.49 133.77,60.88 133.9,61.01 134.16,61.01 134.28,60.88 134.28,60.49 134.41,60.36 137.36,60.36 138.03,59.69 138.03,57.55 v1(137.58,57.11)
  BOTTOM w0.089: v1(108.24,59.34) U22.AR5
M_B_DQ49: length 39.7
  TOP w0.127: v1(135.99,53.07) 136.64,53.07 137.01,52.71 U9.H2
  IN1 w0.089: 111.24,54.38 109.99,54.38 108.48,55.89 107.55,55.89 106.96,56.48 v1(106.81,56.48)
  IN1 w0.127: 111.24,54.38 111.81,53.81 115.71,53.81 120.3,58.41 125.36,58.41 128.95,54.81 129.93,54.81 130.08,54.66 130.08,53.8 130.23,53.64 130.43,53.64 130.59,53.8 130.59,54.66 130.74,54.81 131.19,54.81 131.52,54.48 131.52,54.3 131.21,53.99 131.21,53.76 131.35,53.63 131.57,53.63 131.88,53.94 132.06,53.94 133.3,52.7 135.62,52.7 v1(135.99,53.07)
  BOTTOM w0.089: v1(106.81,56.48) U22.BA8
M_B_DQ50: length 37.9
  TOP w0.14: v1(136.78,57.91) U9.H8
  IN1 w0.127: v1(136.78,57.91) 134.76,59.93 132.43,59.93 132.31,60.06 132.31,60.53 132.18,60.65 131.93,60.65 131.8,60.53 131.8,60.06 131.67,59.93 131.42,59.93 131.29,60.06 131.29,60.53 131.16,60.65 130.91,60.65 130.78,60.53 130.78,60.06 130.66,59.93 130.4,59.93 130.28,60.06 130.28,60.53 130.15,60.65 129.89,60.65 129.77,60.53 129.77,60.06 129.64,59.93 129.39,59.93 129.26,60.06 129.26,60.53 129.13,60.65 128.88,60.65 128.75,60.53 128.75,60.06 128.62,59.93 128.18,59.93 126.6,61.51 118.04,61.51 115.65,59.12 108.91,59.12 108.57,58.77 107.98,58.77 v1(107.53,58.32)
  BOTTOM w0.089: U22.AU7 107.53,58.39 v1(107.53,58.32)
M_B_DQ51: length 37.2
  TOP w0.14: v1(136.78,57.11) U9.H7
  IN1 w0.127: v1(136.78,57.11) 136.78,57.15 135.6,58.33 134.24,58.33 134.12,58.46 134.12,59.16 133.97,59.31 133.76,59.31 133.61,59.16 133.61,58.48 133.35,58.22 132.98,58.22 132.72,58.48 132.72,59.23 132.47,59.49 128.02,59.49 126.46,61.05 118.19,61.05 115.3,58.16 115.12,58.16 114.59,58.68 114.38,58.68 114.23,58.54 114.23,58.33 114.76,57.8 114.76,57.62 114.62,57.48 110.04,57.48 109.18,58.34 v1(108.19,58.34)
  BOTTOM w0.089: v1(108.19,58.34) 108.19,58.56 U22.AU5
M_B_DQ52: length 38.4
  TOP w0.127: U9.J3 137.93,53.51 v1(137.58,53.86)
  IN1 w0.089: v1(108.24,56.48) 108.65,56.48 109.86,55.27 111.83,55.27
  IN1 w0.127: v1(137.58,53.86) 136.94,54.51 136.48,54.51 136.09,54.11 135.16,54.11 134.67,54.61 133.94,54.61 133.76,54.79 133.27,54.79 132.38,55.68 129.31,55.68 125.72,59.27 118.93,59.27 116.01,56.35 116.01,56.17 116.32,55.85 116.32,55.64 116.17,55.49 115.96,55.49 115.65,55.81 115.47,55.81 115.29,55.63 115.29,55.45 115.6,55.14 115.6,54.92 115.45,54.78 115.24,54.78 114.75,55.27 113.75,55.27 113.62,55.14 113.62,54.84 113.49,54.71 113.24,54.71 113.11,54.84 113.11,55.14 112.98,55.27 111.83,55.27
  BOTTOM w0.089: v1(108.24,56.48) U22.BA5
M_B_DQ53: length 38.1
  TOP w0.127: U9.H3 137.18,53.51 136.83,53.86 v1(136.83,53.91)
  IN1 w0.089: 111.52,54.71 110.01,54.71 108.64,56.08 107.93,56.08 v1(107.53,56.48)
  IN1 w0.127: v1(136.83,53.91) 136.6,53.68 135.19,53.68 134.58,54.29 132.99,54.29 132.04,55.24 129.13,55.24 125.54,58.84 119.11,58.84 118.48,58.21 118.48,57.2 118.33,57.04 118.15,57.04 117.89,57.3 117.68,57.3 117.53,57.15 117.53,56.94 117.79,56.68 117.79,56.5 117.61,56.32 117.43,56.32 117.16,56.59 116.95,56.59 116.8,56.44 116.8,56.23 117.07,55.96 117.07,55.78 115.53,54.24 111.99,54.24 111.52,54.71
  BOTTOM w0.089: v1(107.53,56.48) U22.BA7
M_B_DQ54: length 38.8
  TOP w0.14: v1(135.19,57.11) 135.58,56.72 U9.F7
  IN1 w0.127: v1(135.19,57.11) 134.74,56.65 134.07,56.65 133.22,57.5 131.86,57.5 131.12,58.24 131.12,58.89 130.96,59.05 130.72,59.05 130.55,58.89 130.55,57.65 130.4,57.5 130.19,57.5 130.04,57.65 130.04,58.88 129.9,59.03 129.69,59.03 129.54,58.88 129.54,57.86 129.39,57.71 129.18,57.71 129.03,57.86 129.03,58.78 128.81,59 127.89,59 126.28,60.62 118.37,60.62 114.8,57.05 109.81,57.05 108.97,57.88 107.27,57.88 v1(106.84,58.32)
  BOTTOM w0.089: v1(106.84,58.32) 106.84,58.35 U22.AU8
M_B_DQ55: length 40.3
  TOP w0.127: U9.G2 136.5,52.71 136.86,52.35 137.3,52.35 137.58,52.62 v1(137.58,53.16)
  IN1 w0.089: 110.96,54.05 109.04,54.05 107.16,55.93 106.71,55.93 v1(106.08,56.56)
  IN1 w0.127: 110.96,54.05 111.63,53.38 115.89,53.38 120.48,57.97 125.17,57.97 130.04,53.1 132.1,53.1 133.34,51.86 136.29,51.86 v1(137.58,53.16)
  BOTTOM w0.089: v1(106.08,56.56) 105.81,56.88 U22.BA10
M_B_DQ56: length 37.7
  TOP w0.203: U9.C2 133.31,52.71 133.56,52.96 133.56,53.85 132.7,54.71 129.56,54.71 126.12,58.15 126.12,62.34 v1(126.26,62.48)
  IN3 w0.178: v1(112.12,59.97) 112.12,60.89 113.62,62.38 122.84,62.38 123.02,62.56 123.02,63.25 123.22,63.46 123.52,63.46 123.73,63.25 123.73,62.56 123.91,62.38 124.26,62.38 124.44,62.56 124.44,63.23 124.65,63.44 124.94,63.44 125.15,63.23 125.15,62.56 125.33,62.38 126.16,62.38 v1(126.26,62.48)
  BOTTOM w0.079: v1(112.12,59.97) 111.53,60.56 109.97,60.56 109.79,60.37 109.56,60.37 109.23,60.05 U22.AP3
M_B_DQ57: length 36.1
  TOP w0.203: v1(132.11,62.71) 131.91,62.51 131.91,59.46 132.77,58.6 132.77,58.16 133.18,57.76 U9.C8
  IN3 w0.178: v1(132.11,62.71) 132.11,61.02 130.58,59.48 129.61,59.48 129.43,59.66 129.43,60.06 129.19,60.3 128.91,60.3 128.72,60.1 128.72,59.66 128.54,59.48 118.6,59.48 118.4,59.28 118.4,58.73 118.19,58.52 117.9,58.52 117.69,58.73 117.69,59.28 117.49,59.48 116.84,59.48 116.64,59.28 116.64,59.03 117.01,58.65 117.01,58.36 116.8,58.15 116.51,58.15 116.13,58.52 115.88,58.52 115.51,58.15 v1(113.72,58.15)
  BOTTOM w0.089: v1(113.72,58.15) 112.77,59.1 109.96,59.1 109.75,58.89 109.48,58.89 U22.AU2
M_B_DQ58: length 37.4
  TOP w0.203: v1(132.87,62.71) 132.49,62.33 132.49,60.28 133.61,59.17 133.61,58.79 133.59,58.76 133.59,57.1 U9.D7
  IN3 w0.178: v1(113.09,58.15) 113.09,57.91 113.33,57.67 118.02,57.67 119.36,59 130.78,59 132.59,60.82 132.59,61.39 133.65,62.45 133.65,63.49 133.46,63.68 133.15,63.68 132.96,63.49 132.96,62.8 v1(132.87,62.71)
  BOTTOM w0.089: U22.AV3 109.22,58.4 109.35,58.4 109.51,58.51 109.63,58.51 110.04,58.93 112.31,58.93 v1(113.09,58.15)
M_B_DQ59: length 37.9
  TOP w0.203: v1(130.64,62.74) 130.84,62.53 130.84,61.8 130.61,61.56 130.17,61.56 129.93,61.32 129.93,60.99 130.17,60.75 130.59,60.75 130.79,60.55 130.79,59.82 130.44,59.46 130.44,57.55 130.87,57.12 131.99,57.12 U9.B8
  IN3 w0.178: v1(111.18,58.15) 111.18,58.62 111.68,59.12 115.11,59.12 116.44,60.45 127.58,60.45 129.26,62.13 129.26,64.66 129.47,64.87 129.77,64.87 129.98,64.66 129.98,62.96 130.21,62.74 v1(130.64,62.74)
  BOTTOM w0.089: U22.AW3 108.89,57.79 109.08,57.98 109.16,58.04 109.21,58.07 109.32,58.07 109.38,58.06 109.47,57.99 109.51,57.97 109.54,57.97 109.69,57.97 110.27,58.55 110.79,58.55 v1(111.18,58.15)
M_B_DQ60: length 36.8
  TOP w0.203: U9.D3 133.91,53.58 133.91,54.21 132.9,55.22 129.78,55.22 128.41,56.58 128.41,57.95 128.11,58.26 127.04,58.26 126.8,58.5 126.8,58.83 127.04,59.07 128.11,59.07 128.35,59.31 128.35,59.65 128.11,59.88 126.99,59.88 126.71,60.16 126.71,62.25 v1(126.96,62.5)
  IN3 w0.178: v1(112.76,59.97) 112.76,60.84 113.82,61.9 126.36,61.9 v1(126.96,62.5)
  BOTTOM w0.089: U22.AN2 109.28,60.5 109.46,60.67 109.84,60.67 109.89,60.72 112,60.72 v1(112.76,59.97)
M_B_DQ61: length 36.8
  TOP w0.203: U9.C3 132.78,53.11 132.14,53.11 131.96,53.29 131.96,53.79 131.68,54.07 129.48,54.07 125.62,57.94 125.62,62.73 126.39,63.51 v1(127.03,63.51)
  IN3 w0.178: v1(127.03,63.51) 126.11,63.51 125.56,64.06 121.83,64.06 121.38,64.5 121,64.5 119.36,62.86 113.42,62.86 110.85,60.3 v1(110.85,59.97)
  BOTTOM w0.079: U22.AP1 109.74,60.05 110.07,60.38 110.44,60.38 v1(110.85,59.97)
M_B_DQ62: length 37.6
  TOP w0.203: U9.A3 129.33,53.51 125.11,57.73 125.11,57.98 124.9,58.19 124.1,58.19 123.86,58.42 123.86,58.76 124.1,59 124.9,59 125.11,59.2 125.11,62.94 126.17,64.01 v1(126.3,64.01)
  IN3 w0.178: v1(126.3,64.01) 125.76,64.54 122.03,64.54 121.58,64.98 120.8,64.98 119.16,63.35 113.22,63.35 110.22,60.35 v1(110.22,59.97)
  BOTTOM w0.089: U22.AR3 109.1,59.8 109.16,59.84 109.21,59.87 109.35,59.87 109.41,59.84 109.47,59.8 109.47,59.8 109.56,59.77 110.02,59.77 v1(110.22,59.97)
M_B_DQ63: length 36.7
  TOP w0.203: U9.C7 132.77,57.12 132.77,57.66 132.52,57.91 131.44,57.91 131.12,58.23 131.12,59.21 131.35,59.43 v1(131.35,62.71)
  IN3 w0.178: v1(111.82,58.15) 111.82,58.24 112.21,58.63 115.31,58.63 116.64,59.97 127.78,59.97 128.82,61.01 129.16,61.01 130.15,60.03 130.44,60.03 130.65,60.24 130.65,60.53 129.78,61.4 129.78,61.7 129.99,61.9 130.28,61.9 131.1,61.08 131.4,61.08 131.61,61.29 131.61,61.58 131.04,62.15 131.04,62.4 v1(131.35,62.71)
  BOTTOM w0.089: U22.AV1 110.08,58.72 111.25,58.72 v1(111.82,58.15)
M_B_DQSN0: length 49.2
  BOTTOM w0.089: U22.BK25 99.13,52.08 98.89,51.84 98.89,51.06 99.1,50.85 99.1,46.85 99.2,46.75 99.2,46.66 99.22,46.64
  BOTTOM w0.102: 131.6,36.24 131.63,36.24 131.68,36.29 131.83,36.29 132.01,36.12 132.01,35.84 131.9,35.73 U30.A7
  BOTTOM w0.203: 99.22,46.64 100.53,45.33 100.53,43.16 107.22,36.47 107.83,36.47 v1(108.31,35.99) 108.79,36.47 109.16,36.47 112.51,33.12 116.29,33.12 117.33,34.16 118.17,34.16 119.02,33.31 128.31,33.31 131.24,36.24 131.6,36.24
M_B_DQSN1: length 57
  IN1 w0.089: 99.04,50 99.02,50.03 99.02,50.6 98.76,50.85 98.76,52.86 99.23,53.34 99.23,54.6 99.34,54.71 99.55,54.71 99.62,54.63 v1(99.62,54.41)
  IN1 w0.152: v1(133.91,37.48) 134.12,37.48 134.25,37.36 134.25,37.14 134.04,36.93 131.69,36.93 130.04,35.27 128.57,35.27 126.44,33.15 112.32,33.15 109.59,35.88 107.79,35.88 99.04,44.63 99.04,50
  BOTTOM w0.089: U22.BF25 v1(99.62,54.41)
  BOTTOM w0.127: U30.F3 135.93,38.93 136,38.86 136,38.72 135.27,37.99 134.59,37.99 134.08,37.48 v1(133.91,37.48)
M_B_DQSN2: length 43.8
  TOP w0.127: U13.F3 135.19,36.12 135.19,36.1 v1(135.18,36.09)
  IN3 w0.178: v1(112.49,42.49) 112.75,42.24 112.75,41.92 118.02,36.65 134.46,36.65 134.81,36.3 134.98,36.3 v1(135.18,36.09)
  BOTTOM w0.089: U22.BJ18 102.16,52.68 102.08,52.52 102.02,52.41 102.02,51.56 102.35,51.22 102.35,49.1 103.1,48.36 103.1,48.27 103.12,48.25
  BOTTOM w0.203: 103.12,48.25 105.04,46.33 105.04,46.01 107.31,43.74 111.87,43.74 112.7,42.91 112.7,42.7 v1(112.49,42.49)
M_B_DQSN3: length 48.4
  TOP w0.203: U13.A7 131.83,38.68 131.83,38.5 131.54,38.22 129.76,38.22 128.99,38.99 123.32,38.99 122.51,38.17 122.51,37.85 v1(122.28,37.62)
  IN1 w0.089: v1(100.58,58.67) 101.27,57.99 101.27,56.84 101.72,56.39 101.72,54.63 101.86,54.48 101.86,53.42 102.11,53.17 102.11,50.86 102.53,50.43 102.53,50.38
  IN1 w0.152: 102.53,50.38 103.36,49.55 103.36,46.28 108.02,41.62 110.88,41.62 111.55,40.94 112.69,40.94 115.51,38.12 122.35,38.12 122.51,37.97 122.51,37.85 v1(122.28,37.62)
  BOTTOM w0.089: v1(100.58,58.67) 100.61,58.67 U22.AV21
M_B_DQSN4: length 46.7
  IN3 w0.089: v1(103.97,59.34) 104.24,59.07 104.24,58.91 104.41,58.74 108.35,58.74 108.64,58.45 108.64,57.23 109.07,56.8 109.07,55.7 110,54.77 111.23,54.77 111.28,54.72
  IN3 w0.178: 111.28,54.72 113.17,54.72 115.67,52.22 116.14,52.22 116.8,51.56 116.8,51.12 120.67,47.24 124.17,47.24 125.52,45.9 127.42,45.9 128.79,47.27 128.79,51.21 133.74,56.16 135.06,56.16 v1(135.29,55.93)
  BOTTOM w0.089: v1(103.97,59.34) U22.AR15
  BOTTOM w0.14: U25.F3 135.29,56.42 v1(135.29,55.93)
M_B_DQSN5: length 29.9
  BOTTOM w0.089: 112.88,55.5 112.86,55.5 112.79,55.56 110.56,55.56 110.12,56 109.29,56 U22.BC2
  BOTTOM w0.102: U25.A7 131.8,53.29 131.93,53.29 132.03,53.39 132.03,53.72 131.68,54.07 131.25,54.07 131.2,54.02 131.17,54.02
  BOTTOM w0.203: 131.17,54.02 130.8,54.02 128.56,56.27 128.56,57.89 127.32,59.12 120.7,59.12 120.13,59.69 119.13,59.69 117.68,58.25 117.68,57.56 117.48,57.36 v1(117.48,56.68) 116.72,56.68 116.56,56.51 116.18,56.51 115.17,55.5 112.88,55.5
M_B_DQSN6: length 36
  TOP w0.127: v1(134.27,55.13) 134.27,55.13 134.51,54.9 134.51,54.33 134.95,53.88 135.68,53.88 135.81,53.76 135.81,53.58 135.74,53.51 U9.F3
  IN1 w0.089: 112.05,55.87 112.01,55.9 111.26,55.9 110.98,55.62 110.24,55.62 108.99,56.88 107.45,56.88 106.9,57.43 v1(106.81,57.43)
  IN1 w0.152: 112.05,55.87 114.75,55.87 118.7,59.81 125.95,59.81 129.06,56.7 132.89,56.7 133.74,55.85 134.21,55.85 134.53,55.54 134.53,55.39 v1(134.27,55.13)
  BOTTOM w0.089: v1(106.81,57.43) U22.AW8
M_B_DQSN7: length 32.5
  TOP w0.203: v1(128.38,63.45) 128.63,63.19 128.89,63.19 129.32,62.75 129.32,57.17 130.33,56.16 131.63,56.16 131.76,56.28 131.76,56.53 U9.A7
  IN3 w0.178: v1(128.38,63.45) 128.15,63.22 127.88,63.22 127.57,62.9 127.57,62.27 126.6,61.31 114.92,61.31 114.2,60.6 114.2,60.14 v1(114.03,59.97)
  BOTTOM w0.089: U22.AT3 109.31,59.27 109.36,59.32 109.66,59.47 114.12,59.47 114.26,59.61 114.26,59.74 v1(114.03,59.97)
M_B_DQSP0: length 49.2
  BOTTOM w0.089: U22.BJ24 99.37,52.52 99.3,52.4 99.3,52.01 99.07,51.78 99.07,51.13 99.28,50.93 99.28,46.93 99.33,46.87 99.42,46.87 99.44,46.85
  BOTTOM w0.102: U30.B7 132.21,35.9 132.21,36.2 131.92,36.5 131.68,36.5 131.63,36.55 131.6,36.55
  BOTTOM w0.203: 131.6,36.55 131.11,36.55 128.18,33.61 119.15,33.61 118.3,34.47 117.2,34.47 116.16,33.42 112.64,33.42 109.28,36.78 108.79,36.78 v1(108.31,37.26) 107.83,36.78 107.35,36.78 100.83,43.29 100.83,45.46 99.44,46.85
M_B_DQSP1: length 57
  IN1 w0.089: v1(99.63,55.12) 99.4,54.89 99.27,54.89 99.06,54.67 99.06,53.41 98.58,52.94 98.58,50.78 98.84,50.52 98.84,50.05 98.79,50
  IN1 w0.152: v1(134.67,37.48) 134.5,37.31 134.5,37.03 134.15,36.68 131.8,36.68 130.14,35.02 128.67,35.02 126.54,32.89 112.22,32.89 109.49,35.62 107.69,35.62 98.79,44.52 98.79,50
  BOTTOM w0.089: U22.BD25 v1(99.63,55.12)
  BOTTOM w0.127: v1(134.67,37.48) 134.95,37.76 135.36,37.76 136.23,38.63 136.23,38.78 U30.G3
