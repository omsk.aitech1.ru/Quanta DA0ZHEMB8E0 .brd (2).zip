# Allegro board Quanta ZHE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_A13: length 43
  IN3 w0.178: v1(91.14,50.42) 91.05,50.42 90.38,49.75 90.38,46.16 89.41,45.19 89.41,33.91 89.23,33.73 88.34,33.73 88.13,33.53 88.13,33.17 88.28,33.02 89.23,33.02 89.41,32.84 89.41,32.48 89.23,32.31 88.34,32.31 88.13,32.1 88.13,31.75 88.28,31.6 89.23,31.6 89.41,31.42 89.41,31.06 89.23,30.88 88.18,30.88 87.98,30.68 87.98,30.33 88.13,30.17 89.23,30.17 89.41,30 89.41,28.92 87.94,27.45 87.94,24.08 v1(88.55,23.47)
  BOTTOM w0.089: v1(91.14,50.42) 91.65,50.93 91.65,52.13 91.74,52.22 91.74,52.45 91.54,52.65 91.39,52.65 91.19,52.85 91.19,52.86 91.19,52.86 91.19,53.06 91.19,53.06 91.19,53.07 91.29,53.17 91.29,53.39 91.09,53.59 U22.BH43
  BOTTOM w0.203: v1(88.55,23.47) 88.53,23.44 JDIM1.158
M_A_ACT#: length 46.5
  IN1 w0.127: v1(91.55,54.48) 92.38,54.48 92.82,54.05 92.82,53.21 91.55,51.94 86.85,51.94 81.4,46.49 81.4,39.03 77.83,35.46 77.83,30.71 77.15,30.02 77.15,28.14 75.9,26.89 75.9,24.21 v1(76.54,23.57)
  BOTTOM w0.089: U22.BF41 91.83,54.76 v1(91.55,54.48)
  BOTTOM w0.203: v1(76.54,23.57) 75.55,22.58 75.55,20.1 JDIM1.114
M_A_ALERT#: length 2.8
  TOP w0.14: R330.2 75.09,19.04 v1(75.34,18.79)
  BOTTOM w0.14: JDIM1.116 76.02,19.15 75.67,18.79 v1(75.34,18.79)
M_A_BA#0: length 42.6
  IN3 w0.089: v1(90.61,55.12) 90.13,54.64 90.13,54.13 90.05,54.04 90.05,52.42
  IN3 w0.178: 90.05,52.42 90.05,51 89.62,50.57 89.62,46.59 88.01,44.98 88.01,39.45 87.37,38.81 87.37,38.5 87.55,38.32 88.15,38.32 88.37,38.1 88.37,37.82 88.17,37.61 87.55,37.61 87.37,37.44 87.37,31.55 86.49,30.67 86.49,29.94 86.31,29.76 85.71,29.76 85.53,29.58 85.53,29.22 85.71,29.05 86.31,29.05 86.49,28.87 86.49,28.51 86.31,28.34 85.71,28.34 85.53,28.16 85.53,27.8 85.71,27.62 86.31,27.62 86.49,27.45 86.49,24.57 v1(85.67,23.75)
  BOTTOM w0.089: U22.BD43 90.97,55.47 v1(90.61,55.12)
  BOTTOM w0.203: JDIM1.150 86.53,21.63 86.09,22.07 86.09,23.33 v1(85.67,23.75)
M_A_BA#1: length 38.9
  IN3 w0.089: 86.37,50.54 86.32,50.59 86.32,51.28 87.2,52.16 87.2,52.7 87.68,53.18 v1(87.68,53.95)
  IN3 w0.178: v1(82.19,26.25) 82.34,26.25 82.84,26.75 82.84,27.62 82.66,27.8 81.62,27.8 81.44,27.98 81.44,28.33 81.62,28.51 82.75,28.51 83.55,29.32 83.55,30.03 83.38,30.2 82.73,30.2 82.53,30.41 82.53,30.71 82.73,30.92 83.38,30.92 83.55,31.09 83.55,33.44 85.46,35.35 85.46,47.43 86.37,48.33 86.37,50.54
  BOTTOM w0.089: v1(87.68,53.95) 87.67,53.94 U22.BH51
  BOTTOM w0.203: v1(82.19,26.25) 82.24,26.25 83.29,27.3 84.99,27.3 85.28,27.59 JDIM1.145
M_A_BG#0: length 39.9
  IN1 w0.127: v1(83.67,45.46) 82.32,44.11 82.32,39.23 80.47,37.38 80.47,37.2 80.94,36.72 80.94,36.51 80.8,36.36 80.58,36.36 80.11,36.84 79.93,36.84 79.75,36.66 79.75,36.48 80.17,36.05 80.17,35.84 80.03,35.69 79.82,35.69 79.39,36.12 79.21,36.12 78.42,35.33 78.42,35.04 78.54,34.91 79.15,34.91 79.28,34.79 79.28,34.53 79.15,34.4 78.54,34.4 78.42,34.28 78.42,34.02 78.54,33.9 79.15,33.9 79.28,33.77 79.28,33.52 79.15,33.39 78.54,33.39 78.42,33.26 78.42,28.6 76.79,26.97 76.79,26.43 v1(76.32,25.96)
  BOTTOM w0.089: U22.BL50 88.07,52.22 88.07,52.14 88.04,52.11 88.04,51.82 87.79,51.57 87.79,51.2 87.05,50.47 86.92,50.47 86.79,50.33
  BOTTOM w0.203: 86.79,50.33 83.67,47.22 v1(83.67,45.46) ; JDIM1.115 75.78,27.33 75.76,27.32 75.76,26.27 76.07,25.96 v1(76.32,25.96)
M_A_BG#1: length 42.3
  IN3 w0.089: v1(90.61,54.41) 90.61,54.53 91.1,55.02 91.1,56.08 90.82,56.36 89.85,56.36 89.62,56.13 89.22,56.13 88.99,55.91 87.17,55.91 85.33,54.07 85.31,54.07
  IN3 w0.178: v1(76.03,31.14) 76.03,32.18 80.33,36.48 80.33,36.73 79.91,37.15 79.91,37.4 80.16,37.66 80.41,37.66 80.83,37.23 81.08,37.23 81.33,37.49 81.33,37.74 80.91,38.16 80.91,38.41 81.16,38.66 81.42,38.66 81.84,38.24 82.09,38.24 82.46,38.61 82.46,47.82 83.85,49.22 83.85,52.61 85.31,54.07
  BOTTOM w0.089: v1(90.61,54.41) 90.97,54.76 U22.BF43
  BOTTOM w0.203: v1(76.03,31.14) 75.37,30.48 75.37,29.28 75.28,29.19 JDIM1.113
M_A_CAS#: length 40.4
  IN1 w0.127: v1(86.72,50.83) 87.18,50.38 87.18,46.79 87.05,46.67 86.34,46.67 86.21,46.54 86.21,46.29 86.34,46.16 87.05,46.16 87.18,46.03 87.18,32.67 88.3,31.55 88.3,28.73 90.33,26.69 90.33,24.51 89.87,24.05 88,24.05 v1(87.42,24.63)
  BOTTOM w0.089: U22.BJ50 87.95,52.51 87.89,52.46 87.89,52.23 87.86,52.2 87.86,51.89 87.52,51.55 87.52,51.38 86.98,50.83 v1(86.72,50.83)
  BOTTOM w0.203: v1(87.42,24.63) 88.02,24.03 JDIM1.156
M_A_CB0: length 2.4
  TOP w0.14: R327.2 v1(70.26,18.77)
  BOTTOM w0.14: v1(70.26,18.77) 70.03,19.01 JDIM1.92
M_A_CB1: length 2.4
  TOP w0.127: R304.2 69.32,27.49 v1(69.85,26.97)
  BOTTOM w0.102: JDIM1.91 69.78,27.04 v1(69.85,26.97)
M_A_CB2: length 2.3
  TOP w0.14: v1(72.3,29.56) 72.37,29.49 R307.2
  BOTTOM w0.14: v1(72.3,29.56) 72.28,29.54 JDIM1.101
M_A_CB3: length 2.6
  TOP w0.14: v1(73.64,29.59) 73.39,29.34 R308.2
  BOTTOM w0.14: JDIM1.105 73.28,29.35 73.51,29.59 v1(73.64,29.59)
M_A_CB4: length 2.3
  TOP w0.14: R326.2 69.12,18.94 v1(68.97,18.79)
  BOTTOM w0.14: JDIM1.88 69.03,18.84 v1(68.97,18.79)
M_A_CB5: length 2.4
  TOP w0.127: v1(68.71,26.97) 68.31,27.38 R303.2
  BOTTOM w0.102: JDIM1.87 68.78,27.03 v1(68.71,26.97)
M_A_CB6: length 2.4
  TOP w0.14: v1(71.79,18.79) 71.53,19.04 R328.2
  BOTTOM w0.14: v1(71.79,18.79) 72.03,19.03 JDIM1.100
M_A_CB7: length 2.3
  TOP w0.14: v1(72.86,21.35) 72.68,21.17 R329.2
  BOTTOM w0.14: v1(72.86,21.35) 73.03,21.18 JDIM1.104
M_A_CKE0: length 38.4
  IN1 w0.127: v1(80.65,47.8) 79.1,46.25 79.1,39.5 75.9,36.29 75.9,34.47 75.62,34.19 75.44,34.19 75.1,34.53 74.89,34.53 74.75,34.38 74.75,34.17 75.08,33.83 75.08,33.65 72.86,31.42 72.86,26.53 v1(73.28,26.11)
  BOTTOM w0.089: 84.87,52.5 84.87,52.75 84.61,53.01 84.61,53.64 85.44,54.47 85.84,54.47 U22.BF55
  BOTTOM w0.203: v1(73.28,26.11) 74.28,27.11 JDIM1.109 ; v1(80.65,47.8) 80.91,47.8 84.87,51.75 84.87,52.5
M_A_CKE1: length 40.9
  IN1 w0.127: v1(80.63,46.48) 79.61,45.46 79.61,39.34 76.36,36.09 76.36,34.16 74.17,31.98 74.17,23.34 v1(73.65,22.81)
  BOTTOM w0.089: 85.28,51.59 85.28,52.8 84.86,53.22 84.86,53.55 85.59,54.29 85.92,54.29 85.92,54.3 86.29,54.3 U22.BF54
  BOTTOM w0.203: 85.28,51.59 81.64,47.95 81.64,47.5 v1(80.63,46.48) ; v1(73.65,22.81) 74.53,21.94 JDIM1.110
M_A_CLK0: length 40.3
  IN3 w0.089: v1(88.01,54.59) 87.8,54.38 87.57,54.38 87.06,53.87 86.75,53.87 86.48,53.6 86.48,52.18 85.44,51.14 85.44,50.86 85.48,50.82 85.48,50.81
  IN3 w0.127: v1(79.32,31.23) 79.59,31.49 80.17,31.49 80.58,31.9 80.58,32.45 79.89,33.14 79.89,33.4 80.1,33.6 80.33,33.6 81.11,32.82 81.6,32.82 81.91,33.14 81.91,33.63 81.15,34.4 81.15,34.66 81.34,34.85 81.6,34.85 82.33,34.12 82.85,34.12 83.16,34.43 83.16,34.9 82.46,35.6 82.46,35.87 82.64,36.05 82.91,36.05 83.58,35.38 84.08,35.38 84.5,35.8 84.5,47.75 85.48,48.72 85.48,50.81
  BOTTOM w0.089: U22.BE49 88.2,54.86 88.2,54.77 v1(88.01,54.59)
  BOTTOM w0.127: JDIM1.137 81.28,29.2 81.41,29.34 81.41,29.9 79.82,31.49 79.59,31.49 v1(79.32,31.23)
M_A_CLK0#: length 40.3
  IN3 w0.089: 85.22,50.84 85.22,50.87 85.26,50.9 85.26,51.21 86.3,52.25 86.3,53.68 86.68,54.05 86.98,54.05 87.28,54.35 87.28,54.47 v1(87.18,54.57)
  IN3 w0.127: 85.22,50.84 85.22,48.83 84.25,47.85 84.25,35.9 83.98,35.63 83.69,35.63 83.01,36.31 82.54,36.31 82.2,35.97 82.2,35.5 82.91,34.8 82.91,34.54 82.74,34.37 82.43,34.37 81.7,35.1 81.23,35.1 80.9,34.76 80.9,34.29 81.66,33.53 81.66,33.24 81.49,33.08 81.21,33.08 80.43,33.86 79.99,33.86 79.64,33.5 79.64,33.03 80.32,32.35 80.32,32.01 80.06,31.75 79.38,31.75 79.32,31.81 v1(79.32,31.99)
  BOTTOM w0.089: U22.BE51 87.68,54.85 87.39,54.57 v1(87.18,54.57)
  BOTTOM w0.127: v1(79.32,31.99) 79.32,31.81 79.41,31.72 79.92,31.72 81.64,30 81.64,29.34 81.78,29.2 JDIM1.139
M_A_CLK1: length 43.3
  IN3 w0.089: 84.41,51.47 84.41,51.49 84.45,51.53 84.45,51.93 85.66,53.13 85.66,53.92 85.81,54.08 86.86,55.13 87.63,55.13 v1(88.03,55.53)
  IN3 w0.127: v1(81.07,22.06) 81.07,22.24 80.91,22.4 80.43,22.4 79.77,23.06 79.3,23.06 78.47,23.9 78.47,33.66 82.96,38.15 82.96,47.61 84.41,49.06 84.41,51.47
  BOTTOM w0.089: U22.BC49 88.39,55.79 88.13,55.53 v1(88.03,55.53)
  BOTTOM w0.127: v1(81.07,22.06) 81.07,22.26 81.21,22.4 81.47,22.4 81.67,22.2 81.67,21.16 81.53,21.01 JDIM1.138
M_A_CLK1#: length 43.4
  IN3 w0.089: v1(88.75,55.53) 88.28,55.07 87.93,55.07 87.82,54.95 86.94,54.95 85.83,53.85 85.83,53.06 84.63,51.86 84.63,51.53 84.67,51.49 84.67,51.47
  IN3 w0.127: 84.67,51.47 84.67,48.96 83.22,47.51 83.22,38.05 78.72,33.55 78.72,24 79.41,23.32 79.88,23.32 80.54,22.66 80.91,22.66 v1(81.07,22.82)
  BOTTOM w0.089: U22.BC48 89.1,55.89 v1(88.75,55.53)
  BOTTOM w0.127: JDIM1.140 82.02,21.03 81.9,21.15 81.9,22.29 81.56,22.63 81.26,22.63 v1(81.07,22.82)
M_A_CS#0: length 43.5
  IN1 w0.127: v1(85.63,26.32) 86.45,27.14 87.11,27.14 87.26,27.29 87.26,27.5 87.11,27.65 85.78,27.65 85.63,27.8 85.63,28.01 85.78,28.16 87.11,28.16 87.26,28.31 87.26,28.52 87.11,28.67 85.78,28.67 85.63,28.82 85.63,29.03 85.78,29.18 86.77,29.18 86.9,29.3 86.9,29.56 86.77,29.68 85.78,29.68 85.63,29.83 85.63,30.04 85.78,30.19 86.77,30.19 86.9,30.32 86.9,30.57 86.77,30.7 85.78,30.7 85.63,30.85 85.63,31.06 85.78,31.21 86.77,31.21 86.9,31.34 86.9,31.59 86.77,31.72 85.86,31.72 85.63,31.95 85.63,40.1 v1(86.7,41.17)
  BOTTOM w0.089: U22.BJ43 90.88,52.93 90.73,52.71 90.73,52.59 90.84,52.42 90.84,52.22 90.56,51.94 90.56,50.79 90.39,50.63 90.39,49.24
  BOTTOM w0.203: JDIM1.149 86.28,26.97 v1(85.63,26.32) ; 90.39,49.24 90.39,49.12 87.26,45.99 87.26,41.63 86.8,41.17 v1(86.7,41.17)
M_A_CS#1: length 42.6
  IN1 w0.127: v1(86.7,39.9) 86.7,39.33 86.57,39.2 86.09,39.2 85.96,39.07 85.96,38.82 86.09,38.69 86.57,38.69 86.7,38.56 86.7,38.31 86.57,38.18 86.09,38.18 85.96,38.06 85.96,37.8 86.09,37.67 86.57,37.67 86.7,37.55 86.7,37.29 86.57,37.17 86.09,37.17 85.96,37.04 85.96,36.79 86.09,36.66 86.57,36.66 86.7,36.53 86.7,36.28 86.57,36.15 86.09,36.15 85.96,36.02 85.96,35.77 86.09,35.64 86.57,35.64 86.7,35.52 86.7,35.26 86.57,35.13 86.09,35.13 85.96,35.01 85.96,34.75 86.09,34.63 86.57,34.63 86.7,34.5 86.7,34.25 86.57,34.12 86.09,34.12 85.96,33.99 85.96,33.74 86.09,33.61 86.57,33.61 86.7,33.48 86.7,33.23 86.57,33.1 86.09,33.1 85.96,32.98 85.96,32.72 86.09,32.59 86.57,32.59 87.81,31.35 87.81,28.5 89.14,27.18 89.14,25.73 v1(89.7,25.16)
  BOTTOM w0.089: 90.76,49.24 90.76,49.73 90.68,49.81 90.68,50.6 90.76,50.67 90.76,51.89 91.02,52.15 U22.BK43
  BOTTOM w0.203: v1(86.7,39.9) 86.74,39.9 87.66,40.82 87.66,45.82 90.76,48.92 90.76,49.24 ; JDIM1.157 88.28,27.33 89.19,26.41 89.19,25.55 89.58,25.16 v1(89.7,25.16)
M_A_DQ0: length 63.9
  IN1 w0.089: v1(49.61,21.44) 49.88,21.72 49.92,21.72 50.03,21.82 50.03,27.16 52.01,29.14 52.01,30.59 56.59,35.17 59.62,35.17 61.33,36.88 62.67,36.88 67.02,41.22 v1(67.02,44.63)
  BOTTOM w0.089: 81.44,58.67 81.72,58.95 83.73,58.95 84.7,59.93 85.38,59.93 85.56,59.75 85.63,59.75 85.63,59.75 86.03,59.75 86.07,59.78 86.21,59.88 86.34,59.88 86.58,59.72 86.78,59.72 U22.AR53
  BOTTOM w0.14: 81.44,58.67 80.52,58.67 78.3,56.44 77.99,56.44 77.79,56.25 75.92,56.25 75.6,55.93 75.6,55.93 71.47,51.8 69.43,51.8 68.76,51.13 68.76,49.71 67.93,48.87 67.93,45.53 v1(67.02,44.63) ; JDIM1.8 49.03,21.04 49.43,21.44 v1(49.61,21.44)
M_A_DQ1: length 64.3
  IN1 w0.089: v1(67.02,47.04) 66.55,46.57 66.55,42.59 66.05,42.08 66.05,41.78 66.45,41.38 66.45,41.19 66.32,41.06 66.13,41.06 65.72,41.47 65.54,41.47 65.41,41.34 65.41,41.16 65.83,40.73 65.83,40.55 65.7,40.42 65.52,40.42 65.08,40.86 64.89,40.86 64.76,40.73 64.76,40.54 65.2,40.1 65.2,39.92 65.07,39.79 64.89,39.79 64.45,40.23 64.27,40.23 64.13,40.1 64.14,39.91 64.55,39.5 64.55,39.32 64.42,39.19 64.23,39.19 63.82,39.6 63.64,39.6 63.51,39.47 63.51,39.29 63.91,38.89 63.91,38.59 62.53,37.22 61.19,37.22 59.48,35.51 56.45,35.51 51.67,30.73 51.67,29.29 49.61,27.23 v1(49.61,26.66)
  BOTTOM w0.089: U22.AP55 85.89,59.97 85.6,59.97 85.47,60.11 84.63,60.11 84.19,59.67 83.7,59.18 81.52,59.18 81.31,58.98
  BOTTOM w0.14: JDIM1.7 48.78,27.4 49.51,26.66 v1(49.61,26.66) ; v1(67.02,47.04) 67.53,47.55 67.53,49.04 68.37,49.87 68.37,51.3 69.27,52.19 71.31,52.19 75.76,56.64 77.63,56.64 77.83,56.84 78.26,56.84 80.4,58.98 81.31,58.98
M_A_DQ2: length 65.3
  IN1 w0.089: v1(49.61,25.32) 49.21,25.72 49.21,27.31 51.33,29.43 51.33,30.87 56.31,35.86 59.34,35.86 61.65,38.17 61.99,38.17 62.39,37.77 62.57,37.77 62.7,37.9 62.7,38.09 62.23,38.56 62.23,38.75 62.36,38.88 62.54,38.88 63,38.41 63.19,38.41 63.32,38.55 63.32,38.73 62.96,39.09 62.96,39.48 66.21,42.73 66.21,48.18 66.47,48.44 v1(67.07,48.44)
  BOTTOM w0.089: U22.AP53 86.34,60.21 86.21,60.21 86.05,60.32 85.85,60.32 85.83,60.3 84.57,60.3 83.65,59.38 81.31,59.38 81.21,59.28
  BOTTOM w0.14: 81.21,59.28 80.32,59.28 78.27,57.23 77.66,57.23 77.5,57.07 75.44,57.07 70.96,52.59 69.1,52.59 67.94,51.42 67.94,50 67.07,49.13 v1(67.07,48.44) ; JDIM1.3 47.78,27.03 49.49,25.32 v1(49.61,25.32)
M_A_DQ3: length 64.7
  IN1 w0.089: v1(67.09,49.78) 66.72,49.78 65.87,48.93 65.87,42.87 59.2,36.2 56.17,36.2 50.98,31.02 50.98,29.57 48.87,27.45 48.87,25.58 49.21,25.23 49.21,23.23 v1(49.61,22.83)
  BOTTOM w0.089: 81.08,59.61 83.63,59.61 84.51,60.5 U22.AN54
  BOTTOM w0.14: 81.08,59.61 80.21,59.61 78.23,57.63 77.5,57.63 77.34,57.47 75.28,57.47 75.14,57.33 75.14,57.33 70.79,52.98 68.94,52.98 67.54,51.58 67.54,50.24 v1(67.09,49.78) ; v1(49.61,22.83) 49.54,22.83 48.03,21.31 JDIM1.4
M_A_DQ4: length 63.5
  IN1 w0.089: v1(70.07,50.49) 68.99,49.41 68.99,41.44 62.72,35.17 62.52,35.17 62.13,35.56 61.94,35.56 61.81,35.43 61.81,35.25 62.21,34.85 62.21,34.67 62.08,34.54 61.9,34.54 61.47,34.96 61.29,34.96 61.16,34.83 61.16,34.65 61.58,34.23 61.58,34.03 61.46,33.91 57.54,33.91 53.9,30.28 53.9,29.2 52.01,27.31 52.01,22.69 v1(52.75,21.95)
  BOTTOM w0.089: U22.AU54 85.59,58.69 85.51,58.61 84.22,58.61 83.85,58.24 82.3,58.24
  BOTTOM w0.14: v1(52.75,21.95) 52.03,21.23 JDIM1.20 ; 82.3,58.24 80.83,56.77 80.83,56.13 79.64,54.94 76.51,54.94 72.06,50.49 v1(70.07,50.49)
M_A_DQ5: length 64.6
  IN1 w0.089: v1(70.07,49.22) 69.33,48.48 69.33,41.23 64.14,36.04 64.14,35.74 64.55,35.34 64.55,35.15 64.42,35.02 64.23,35.02 63.82,35.43 63.64,35.43 63.51,35.3 63.51,35.12 63.91,34.72 63.91,34.54 63.78,34.41 63.59,34.41 63.18,34.82 62.99,34.82 62.86,34.69 62.86,34.5 63.26,34.1 63.26,33.92 63.13,33.79 62.95,33.79 62.54,34.2 62.35,34.2 61.68,33.53 57.74,33.53 54.24,30.03 54.24,29 52.35,27.11 52.35,23.77 v1(52.75,23.37)
  BOTTOM w0.089: 82.58,58.04 83.95,58.04 84.34,58.43 85.71,58.43 85.78,58.51 86.05,58.51 86.21,58.4 86.34,58.4 U22.AV53
  BOTTOM w0.14: 82.58,58.04 81.13,56.59 81.13,55.95 79.72,54.54 77,54.54 71.68,49.22 v1(70.07,49.22) ; JDIM1.16 51.03,21.06 51.82,21.86 51.82,22.45 v1(52.75,23.37)
M_A_DQ6: length 64.2
  IN1 w0.089: v1(52.78,26.9) 55.3,29.43 55.3,30.18 58.31,33.18 63.14,33.18 65.1,35.15 65.1,35.43 64.66,35.87 64.66,36.05 64.79,36.18 64.97,36.18 65.48,35.68 65.66,35.68 65.79,35.81 65.79,35.99 65.29,36.5 65.29,36.68 65.42,36.81 65.6,36.81 66.11,36.31 66.29,36.31 66.42,36.44 66.42,36.62 65.92,37.12 65.92,37.31 66.05,37.44 66.23,37.44 66.74,36.94 66.92,36.94 67.05,37.07 67.05,37.25 66.56,37.74 66.56,37.92 66.69,38.06 66.87,38.06 67.35,37.58 67.53,37.58 67.66,37.71 67.66,37.89 67.19,38.37 67.19,38.55 67.32,38.68 67.5,38.68 67.99,38.19 68.18,38.19 68.31,38.32 68.31,38.51 67.84,38.97 67.84,39.16 67.97,39.29 68.16,39.29 68.61,38.84 68.79,38.84 68.92,38.97 68.92,39.15 68.48,39.59 68.48,39.77 68.61,39.9 68.8,39.9 69.25,39.45 69.44,39.45 69.67,39.69 69.67,47.55 v1(70.07,47.95)
  BOTTOM w0.089: 84.43,58.23 85.96,58.23 U22.AV55
  BOTTOM w0.14: 84.43,58.23 83.98,57.78 82.79,57.78 81.49,56.49 81.49,55.83 79.81,54.15 77.17,54.15 70.97,47.95 v1(70.07,47.95) ; v1(52.78,26.9) 52.27,27.41 JDIM1.21
M_A_DQ7: length 65.6
  IN1 w0.089: v1(52.75,25.56) 53.37,26.18 53.37,26.92 55.68,29.23 55.68,30.07 58.45,32.84 63.31,32.84 70.02,39.55 70.02,40.91 70.15,41.04 70.82,41.04 70.95,41.17 70.95,41.36 70.82,41.49 70.15,41.49 70.02,41.62 70.02,41.8 70.15,41.93 70.82,41.93 70.95,42.06 70.95,42.24 70.82,42.37 70.15,42.37 70.02,42.51 70.02,42.69 70.15,42.82 70.79,42.82 70.92,42.95 70.92,43.13 70.79,43.26 70.15,43.26 70.02,43.39 70.02,43.58 70.15,43.71 70.79,43.71 70.92,43.84 70.92,44.02 70.79,44.15 70.15,44.15 70.02,44.28 70.02,44.47 70.15,44.6 70.79,44.6 70.92,44.73 70.92,44.91 70.79,45.04 70.15,45.04 70.02,45.17 70.02,45.36 70.15,45.49 70.79,45.49 70.92,45.62 70.92,45.8 70.79,45.93 70.19,45.93 70.07,46.05 v1(70.07,46.68)
  BOTTOM w0.089: U22.AW53 86.67,57.79 86.48,57.98 86.34,58.08 86.21,58.08 86.07,57.98 86.05,57.96 85.22,57.96 85.15,58.03 84.55,58.03 84.23,57.71
  BOTTOM w0.14: v1(52.75,25.56) 52.13,26.18 52.13,26.54 51.27,27.39 JDIM1.17 ; v1(70.07,46.68) 70.43,46.68 77.5,53.76 79.9,53.76 81.82,55.68 81.82,56.34 83.01,57.53 84.06,57.53 84.23,57.71
M_A_DQ8: length 51.9
  IN3 w0.089: v1(87.33,58.39) 87.33,58.39 87.32,58.39 87.05,58.39 85.21,56.55 84.12,56.55 84.03,56.64
  IN3 w0.127: v1(66.22,24.9) 67.16,25.85 67.16,31.34 73.75,37.92 73.75,38.1 73.27,38.58 73.27,38.84 73.46,39.03 73.72,39.03 74.17,38.58 74.43,38.58 74.62,38.77 74.62,39.03 74.15,39.49 74.15,39.75 74.34,39.94 74.6,39.94 75.09,39.45 75.27,39.45 75.54,39.72 75.54,41.14 78.52,44.11 78.52,49.14 80.58,51.2 80.58,53.11 82.73,55.27 82.73,55.96 83.41,56.64 84.03,56.64
  BOTTOM w0.089: v1(87.33,58.39) 87.68,58.74 U22.AU51
  BOTTOM w0.14: JDIM1.67 63.78,27.1 65.97,24.9 v1(66.22,24.9)
M_A_DQ9: length 53.6
  IN3 w0.089: v1(88.75,58.39) 88.75,58.71 88.58,58.88 87.87,58.88 87.79,58.95 87,58.95 86.98,58.93 85.05,57 84.39,57 84.21,57.17 83.88,57.17
  IN3 w0.127: v1(66.22,23.56) 65.86,23.56 65.68,23.73 65.68,27.95 66.28,28.55 66.28,31.82 69.17,34.72 69.17,36.04 77.74,44.61 77.74,49.45 79.81,51.52 79.81,53.36 82.05,55.6 82.05,56.08 83.14,57.17 83.88,57.17
  BOTTOM w0.089: v1(88.75,58.39) 89.1,58.74 U22.AU48
  BOTTOM w0.14: v1(66.22,23.56) 65.49,22.83 65.49,22.59 64.23,21.33 63.86,21.33 63.53,21 JDIM1.66
M_A_DQ10: length 53.6
  IN3 w0.089: v1(88.03,58.39) 87.64,58.78 87.12,58.78 85.14,56.79 84.26,56.79 84.13,56.92
  IN3 w0.127: 84.13,56.92 83.27,56.92 82.38,56.03 82.38,55.42 80.19,53.24 80.19,51.36 78.12,49.29 78.12,44.41 72.32,38.6 72.32,38.42 72.88,37.86 72.88,37.6 72.69,37.41 72.43,37.41 71.89,37.95 71.62,37.95 71.44,37.77 71.44,37.51 71.98,36.96 71.98,36.7 71.8,36.51 71.53,36.51 70.99,37.06 70.73,37.06 70.54,36.87 70.54,36.61 71.08,36.06 71.08,35.8 70.9,35.61 70.63,35.61 70.09,36.16 69.83,36.16 69.64,35.97 69.64,35.71 70.14,35.21 70.14,35.03 66.68,31.57 66.68,26.7 v1(66.22,26.23)
  BOTTOM w0.089: v1(88.03,58.39) 88.39,58.75 U22.AU49
  BOTTOM w0.14: JDIM1.71 64.78,26.64 65.46,25.96 65.94,25.96 v1(66.22,26.23)
M_A_DQ11: length 53.2
  IN3 w0.089: v1(89.43,56.56) 88.94,57.05 86.96,57.05 84.97,55.07 84.28,55.07
  IN3 w0.127: v1(69.88,22.11) 69.17,22.82 69.17,31.22 77.25,39.29 77.25,39.54 76.91,39.87 76.91,40.14 77.1,40.32 77.36,40.32 77.71,39.97 77.97,39.97 78.16,40.16 78.16,40.42 77.81,40.77 77.81,41.03 78,41.22 78.26,41.22 78.61,40.87 78.87,40.87 79.06,41.06 79.06,41.32 78.75,41.63 78.75,41.89 78.94,42.07 79.2,42.07 79.5,41.78 79.74,41.78 80.14,42.19 80.14,48.89 81.9,50.64 81.9,52.68 84.28,55.07
  BOTTOM w0.089: v1(89.43,56.56) 89.81,56.94 U22.BA46
  BOTTOM w0.14: JDIM1.84 68.03,20.95 69.19,22.11 v1(69.88,22.11)
M_A_DQ12: length 55
  IN3 w0.089: 84.57,54.84 85.07,54.84 87.09,56.86 88.37,56.86 v1(88.75,56.48)
  IN3 w0.127: v1(69.85,26.31) 70.26,26.31 70.57,26.62 70.57,30.58 70.75,30.76 70.75,30.94 70.21,31.49 70.21,31.67 70.48,31.94 70.66,31.94 71.2,31.39 71.38,31.39 71.65,31.66 71.65,31.84 71.11,32.39 71.11,32.57 71.37,32.83 71.55,32.83 72.1,32.29 72.28,32.29 72.55,32.56 72.55,32.74 72,33.28 72,33.46 72.27,33.73 72.45,33.73 73,33.19 73.18,33.19 73.45,33.46 73.45,33.64 72.9,34.18 72.9,34.36 73.17,34.63 73.35,34.63 73.89,34.09 74.07,34.09 74.34,34.36 74.34,34.54 73.8,35.08 73.8,35.26 74.07,35.53 74.25,35.53 74.79,34.98 74.97,34.98 75.24,35.25 75.24,35.43 74.7,35.98 74.7,36.16 74.97,36.43 75.15,36.43 75.69,35.88 75.87,35.88 76.08,36.1 76.08,36.35 75.58,36.86 75.58,37.04 81.13,42.59 81.13,49.33 82.28,50.47 82.28,52.55 84.57,54.84
  BOTTOM w0.089: U22.BA48 89.1,56.84 v1(88.75,56.48)
  BOTTOM w0.14: v1(69.85,26.31) 68.77,26.31 67.78,27.3 JDIM1.83
M_A_DQ13: length 53.1
  IN3 w0.089: 85.07,54.41 85.31,54.41 86.49,55.6 87,56.1 87.48,56.1 87.86,56.48 v1(88.03,56.48)
  IN3 w0.127: v1(69.86,23.46) 71.63,23.46 72.8,24.64 72.8,31.56 76.12,34.88 76.3,34.88 76.89,34.29 77.07,34.29 77.34,34.56 77.34,34.74 76.75,35.33 76.75,35.51 77.02,35.78 77.2,35.78 77.79,35.19 77.97,35.19 78.24,35.46 78.24,35.64 77.65,36.23 77.65,36.41 77.92,36.68 78.1,36.68 78.69,36.09 78.87,36.09 79.14,36.36 79.14,36.54 78.55,37.13 78.55,37.31 81.9,40.66 81.9,48.06 83.19,49.35 83.19,52.53 85.07,54.41
  BOTTOM w0.089: U22.BA49 88.39,56.84 v1(88.03,56.48)
  BOTTOM w0.14: JDIM1.80 67.03,20.94 69.55,23.46 v1(69.86,23.46)
M_A_DQ14: length 53.8
  IN3 w0.089: 84.83,54.61 85.2,54.61 87.07,56.48 v1(87.32,56.48)
  IN3 w0.127: v1(69.85,25.04) 71.18,26.36 71.18,30.48 76.89,36.19 76.89,36.37 76.33,36.92 76.33,37.18 76.52,37.37 76.78,37.37 77.28,36.87 77.55,36.87 77.73,37.06 77.73,37.32 77.22,37.83 77.22,38.1 77.41,38.28 77.67,38.28 78.23,37.71 78.41,37.71 78.68,37.98 78.68,38.16 78.1,38.75 78.1,38.93 78.37,39.2 78.55,39.2 79.13,38.61 79.31,38.61 79.58,38.88 79.58,39.06 79,39.64 79,39.82 79.27,40.09 79.45,40.09 80.03,39.51 80.21,39.51 80.48,39.78 80.48,39.96 79.9,40.54 79.9,40.72 80.17,40.99 80.35,40.99 80.93,40.41 81.11,40.41 81.52,40.82 81.52,48.33 82.73,49.55 82.73,52.52 84.83,54.61
  BOTTOM w0.089: v1(87.32,56.48) 87.68,56.84 U22.BA51
  BOTTOM w0.14: JDIM1.79 66.78,27.34 69.08,25.04 v1(69.85,25.04)
M_A_DQ15: length 51.9
  IN3 w0.089: v1(87.33,59.34) 87.11,59.34 85.01,57.24 84.5,57.24 84.31,57.43 83.8,57.43
  IN3 w0.127: v1(66.22,22.24) 65.3,23.16 65.3,28.23 65.82,28.75 65.82,31.93 68.79,34.9 68.79,36.22 76.54,43.97 76.54,48.78 79.41,51.65 79.41,53.47 81.74,55.8 81.74,56.21 82.96,57.43 83.8,57.43
  BOTTOM w0.089: v1(87.33,59.34) 87.68,59.7 U22.AR51
  BOTTOM w0.14: JDIM1.70 64.53,21.03 65.73,22.24 v1(66.22,22.24)
M_A_DQ16: length 52.1
  IN1 w0.089: v1(60.55,21.96) 59.48,23.03 59.48,27.01 62.84,30.37 62.84,31.41 72.32,40.89 72.32,46.58 v1(73.61,47.87)
  BOTTOM w0.089: 83.24,57.3 84.56,57.3 84.61,57.25 85.87,57.25 U22.AY55
  BOTTOM w0.14: v1(73.61,47.87) 73.61,49.09 77.73,53.21 79.84,53.21 82.12,55.5 82.12,56.18 83.24,57.3 ; JDIM1.50 59.53,21.22 60.27,21.96 v1(60.55,21.96)
M_A_DQ17: length 52.7
  IN1 w0.089: v1(73.61,45.33) 73.17,45.33 73.03,45.18 73.03,40.63 65.05,32.65 65.05,32.53 65.44,32.14 65.44,31.95 65.31,31.82 65.13,31.82 64.74,32.21 64.61,32.21 64.42,32.02 64.42,31.9 64.8,31.52 64.8,31.31 60.17,26.67 60.17,24.88 60.29,24.75 v1(60.63,24.75)
  BOTTOM w0.089: 84.11,56.8 84.78,56.8 84.86,56.89 85.51,56.89 85.51,56.89 U22.BA54
  BOTTOM w0.14: v1(60.63,24.75) 59.58,25.81 59.58,26.55 59.16,26.97 58.55,26.97 58.27,27.24 JDIM1.45 ; 84.11,56.8 83.59,56.8 82.75,55.97 82.75,55.26 79.92,52.42 78.06,52.42 74.52,48.88 74.52,46.14 73.71,45.33 v1(73.61,45.33)
M_A_DQ18: length 53.7
  IN1 w0.089: v1(60.63,26.2) 60.63,26.65 66.02,32.04 66.02,32.23 65.68,32.57 65.68,32.75 65.81,32.88 65.99,32.88 66.33,32.54 66.52,32.54 66.65,32.67 66.65,32.85 66.31,33.2 66.31,33.38 66.44,33.51 66.62,33.51 66.96,33.17 67.15,33.17 67.28,33.3 67.28,33.48 66.92,33.84 66.92,34.02 67.05,34.15 67.24,34.15 67.59,33.8 67.77,33.8 67.9,33.93 67.9,34.11 67.56,34.45 67.56,34.64 67.69,34.77 67.88,34.77 68.22,34.43 68.4,34.43 68.53,34.56 68.53,34.74 68.19,35.08 68.19,35.27 68.32,35.4 68.51,35.4 68.85,35.06 69.03,35.06 69.16,35.19 69.16,35.37 68.82,35.71 68.82,35.89 68.95,36.03 69.14,36.03 69.48,35.68 69.66,35.68 69.79,35.81 69.79,36.91 73.37,40.49 73.37,43.82 v1(73.61,44.06)
  BOTTOM w0.089: 84.44,56.59 84.87,56.59 84.99,56.71 86.06,56.71 86.07,56.7 86.21,56.6 86.34,56.6 86.48,56.7 86.67,56.89 U22.BA53
  BOTTOM w0.14: 84.44,56.59 84.16,56.31 84.16,56.13 77.87,49.84 76.49,49.84 74.91,48.26 74.91,45.26 73.71,44.06 v1(73.61,44.06) ; v1(60.63,26.2) 60.37,26.2 59.27,27.3 JDIM1.49
M_A_DQ19: length 53.5
  IN1 w0.089: v1(73.61,46.6) 72.69,45.67 72.69,40.77 64.05,32.13 64.05,31.2 63.94,31.09 63.75,31.09 63.49,31.35 63.31,31.35 63.18,31.22 63.18,31.03 63.43,30.78 63.43,30.48 59.82,26.87 59.82,24.16 v1(60.63,23.36)
  BOTTOM w0.089: 83.42,57.07 85.85,57.07 85.85,57.07 86.06,57.07 86.2,57.18 86.34,57.18 U22.AY53
  BOTTOM w0.14: v1(60.63,23.36) 59.75,22.48 59.75,22.24 58.53,21.02 JDIM1.46 ; v1(73.61,46.6) 73.88,46.6 74.12,46.84 74.12,48.72 74.12,49.05 77.89,52.82 79.88,52.82 82.43,55.37 82.43,56.08 83.42,57.07
M_A_DQ20: length 52.4
  IN1 w0.089: v1(64.04,21.82) 63.75,21.82 62.77,22.81 62.77,26.72 71.5,35.45 71.5,35.63 71.11,36.02 71.11,36.15 71.3,36.34 71.42,36.34 71.84,35.92 72.03,35.92 72.16,36.05 72.16,36.23 71.74,36.65 71.74,36.78 71.92,36.97 72.05,36.97 72.47,36.54 72.66,36.54 72.79,36.67 72.79,36.86 72.36,37.28 72.36,37.41 75.5,40.54 75.5,44.5 76.05,45.05 76.05,47.44 v1(77.13,48.52)
  BOTTOM w0.089: U22.BC53 86.46,55.78 86.34,55.7 86.21,55.7 86.05,55.81 85.84,55.81 85.29,55.26 84.6,55.26 84.27,54.92
  BOTTOM w0.14: 84.27,54.92 83.39,54.05 83.39,53.52 78.4,48.52 v1(77.13,48.52) ; JDIM1.62 62.53,20.95 63.4,21.82 v1(64.04,21.82)
M_A_DQ21: length 52.2
  IN1 w0.089: v1(77.13,47.25) 76.39,46.51 76.39,44.89 75.93,44.42 75.93,39.33 75.7,39.1 75.57,39.1 75.19,39.48 75.07,39.48 74.88,39.29 74.88,39.16 75.26,38.78 75.26,38.66 75.07,38.47 74.94,38.47 74.57,38.85 74.44,38.85 74.25,38.66 74.25,38.53 74.63,38.16 74.63,38.03 74.44,37.84 74.31,37.84 73.94,38.22 73.81,38.22 73.62,38.03 73.62,37.9 74,37.53 74,37.4 73.81,37.21 73.68,37.21 73.31,37.59 73.18,37.59 72.99,37.4 72.99,37.27 73.37,36.9 73.37,36.77 63.11,26.52 63.11,24.18 v1(64.04,23.25)
  BOTTOM w0.089: 84.46,54.65 84.86,55.05 85.44,55.05 85.93,55.54 U22.BD55
  BOTTOM w0.14: 84.46,54.65 84.46,54.63 83.7,53.88 83.7,53.24 77.72,47.25 v1(77.13,47.25) ; JDIM1.58 61.53,21.17 63.6,23.25 v1(64.04,23.25)
M_A_DQ22: length 52.5
  IN1 w0.089: v1(64.04,26.09) 64.04,26.48 68.73,31.16 68.86,31.16 69.39,30.63 69.58,30.63 69.71,30.76 69.71,30.94 69.2,31.45 69.2,31.63 69.33,31.76 69.51,31.76 70.05,31.23 70.23,31.23 70.36,31.36 70.36,31.55 69.83,32.08 69.83,32.26 69.96,32.39 70.14,32.39 70.65,31.89 70.83,31.89 70.96,32.02 70.96,32.2 70.46,32.71 70.46,32.89 70.59,33.02 70.77,33.02 71.29,32.5 71.47,32.5 71.6,32.63 71.6,32.82 71.09,33.33 71.09,33.52 71.22,33.65 71.4,33.65 71.91,33.14 72.09,33.14 72.22,33.27 72.22,33.46 71.72,33.96 71.72,34.15 71.85,34.28 72.03,34.28 72.55,33.76 72.73,33.76 72.86,33.89 72.86,34.07 72.34,34.59 72.34,34.78 72.47,34.91 72.66,34.91 73.16,34.41 73.29,34.41 76.69,37.81 76.69,44.07 77.13,44.51 v1(77.13,44.71)
  BOTTOM w0.089: 84.31,53.72 85.24,54.65 85.6,54.65 86.03,55.08 86.27,55.08 U22.BE54
  BOTTOM w0.14: JDIM1.63 62.78,27.36 v1(64.04,26.09) ; 84.31,53.72 84.31,53.06 83.96,52.71 83.96,52.25 78.02,46.31 78.02,45.5 77.24,44.71 v1(77.13,44.71)
M_A_DQ23: length 53.4
  IN1 w0.089: v1(77.13,45.98) 76.73,45.58 76.73,44.67 76.33,44.27 76.33,39.25 75.69,38.61 75.69,38.48 76.16,38.02 76.16,37.9 75.97,37.71 75.84,37.71 75.38,38.17 75.25,38.17 75.06,37.98 75.06,37.86 75.53,37.39 75.53,37.27 75.34,37.08 75.21,37.08 74.75,37.54 74.62,37.54 74.44,37.35 74.44,37.23 74.9,36.76 74.9,36.64 74.71,36.45 74.58,36.45 74.12,36.91 74,36.91 73.81,36.72 73.81,36.6 74.27,36.13 74.27,35.98 74.11,35.82 73.96,35.82 73.49,36.28 73.37,36.28 73.18,36.09 73.18,35.97 73.64,35.51 73.64,35.35 73.48,35.19 73.33,35.19 72.86,35.65 72.74,35.65 63.46,26.37 63.46,25.26 v1(64.04,24.67)
  BOTTOM w0.089: 84,53.75 85.09,54.84 85.52,54.84 85.94,55.26 86,55.26 86.09,55.29 86.15,55.33 86.21,55.37 U22.BD53
  BOTTOM w0.14: v1(77.13,45.98) 77.24,45.98 77.63,46.38 77.63,46.61 83.6,52.58 83.6,52.73 84,53.14 84,53.75 ; JDIM1.59 61.78,27.27 61.9,27.15 62.51,27.15 63.08,26.57 63.08,25.63 v1(64.04,24.67)
M_A_DQ24: length 63.4
  IN3 w0.089: v1(90.88,60.83) 90.88,60.7 90.56,60.38 89.9,60.38 89.45,60.84 89.44,60.84 89.42,60.86 86.57,60.86 85.63,59.92 84.03,59.92 83.95,59.84
  IN3 w0.127: v1(54.44,22.21) 55.31,22.21 55.66,22.55 55.66,26.29 58.3,28.93 58.3,30.48 64.19,36.37 64.19,37.67 71.84,45.32 71.84,51.85 78.32,58.33 78.5,58.33 80.02,59.84 83.95,59.84
  BOTTOM w0.089: U22.AN43 91.23,60.47 v1(90.88,60.83)
  BOTTOM w0.14: JDIM1.28 54.03,21.03 54.32,21.32 54.32,22.08 v1(54.44,22.21)
M_A_DQ25: length 64.2
  IN3 w0.089: v1(90.17,60.83) 89.71,60.83 89.52,61.02 89.52,61.02 89.5,61.03 86.44,61.03 85.58,60.17 83.19,60.17 83.05,60.31
  IN3 w0.127: 83.05,60.31 79.98,60.31 78.38,58.71 78.17,58.71 71.44,51.98 71.44,45.63 63.78,37.98 63.78,37.55 63.65,37.42 63.07,37.42 62.9,37.24 62.9,36.93 63.04,36.79 63.65,36.79 63.78,36.66 63.78,36.5 57.82,30.53 57.82,29.11 55.28,26.57 55.28,24.48 v1(54.45,23.65)
  BOTTOM w0.089: v1(90.17,60.83) 90.52,60.47 U22.AN44
  BOTTOM w0.14: JDIM1.24 53.03,21.08 53.57,21.62 53.57,22.77 v1(54.45,23.65)
M_A_DQ26: length 64.3
  IN3 w0.089: 83.77,57.74 84.24,57.74 84.56,58.06 85.48,58.06 87.2,59.79 88.3,59.79 v1(88.75,59.34)
  IN3 w0.127: v1(58.95,22.09) 60.18,23.32 60.18,26.38 63.94,30.14 63.94,30.75 63.39,31.31 63.39,31.57 63.57,31.76 63.84,31.76 64.57,31.02 64.83,31.02 65.02,31.2 65.02,31.47 64.28,32.2 64.28,32.47 64.47,32.65 64.73,32.65 65.13,32.26 65.39,32.26 65.58,32.44 65.58,32.71 65.18,33.1 65.18,33.37 65.37,33.55 65.63,33.55 66.03,33.15 66.29,33.15 66.48,33.34 66.48,33.6 66.08,34 66.08,34.26 66.27,34.45 66.53,34.45 66.93,34.05 67.19,34.05 67.38,34.24 67.38,34.5 66.98,34.9 66.98,35.16 67.16,35.35 67.43,35.35 67.87,34.91 68.05,34.91 68.21,35.07 68.21,36.39 76,44.19 76,50.7 81.41,56.11 81.41,56.52 82.63,57.74 83.77,57.74
  BOTTOM w0.089: U22.AR48 89.1,59.7 v1(88.75,59.34)
  BOTTOM w0.14: v1(58.95,22.09) 58.45,22.09 57.53,21.17 JDIM1.42
M_A_DQ27: length 64.2
  IN3 w0.089: v1(91.59,58.39) 91.03,58.95 90.57,58.95 90.57,58.95 89.8,58.95 89.64,59.12 89.64,59.62 88.93,60.32 86.96,60.32 85.31,58.67 83.77,58.67
  IN3 w0.127: v1(58.95,26.51) 58.95,26.81 60.81,28.67 60.81,30.88 66.05,36.12 66.05,36.38 65.58,36.84 65.58,37.02 65.85,37.29 66.03,37.29 66.49,36.83 66.76,36.83 66.94,37.01 66.94,37.28 66.48,37.74 66.48,37.92 66.75,38.19 66.93,38.19 67.4,37.71 67.67,37.71 67.85,37.9 67.85,38.16 67.38,38.64 67.38,38.82 67.65,39.09 67.83,39.09 68.3,38.61 68.57,38.61 68.75,38.8 68.75,39.06 68.27,39.54 68.27,39.72 68.54,39.99 68.72,39.99 69.19,39.52 69.45,39.52 69.64,39.71 69.64,39.97 69.25,40.36 69.25,40.69 73.16,44.61 73.16,51.3 80.53,58.67 83.77,58.67
  BOTTOM w0.089: v1(91.59,58.39) 91.95,58.74 U22.AU41
  BOTTOM w0.14: JDIM1.41 57.27,27.25 58.01,26.51 v1(58.95,26.51)
M_A_DQ28: length 66.5
  IN3 w0.089: v1(90.88,58.39) 90.49,58.77 89.73,58.77 89.41,59.09 89.41,59.57 88.83,60.14 87.03,60.14 86.47,59.58 85.33,58.44 84.23,58.44 84.13,58.34 83.77,58.34
  IN3 w0.127: 83.77,58.34 80.74,58.34 74.41,52.01 74.41,43.75 73.82,43.15 73.64,43.15 73.08,43.71 72.9,43.71 72.63,43.44 72.63,43.26 73.19,42.7 73.19,42.52 72.92,42.25 72.74,42.25 72.18,42.81 72,42.81 71.73,42.54 71.73,42.36 72.29,41.81 72.29,41.63 72.02,41.36 71.84,41.36 71.29,41.91 71.11,41.91 70.84,41.64 70.84,41.46 71.39,40.91 71.39,40.73 71.12,40.46 70.94,40.46 70.39,41.01 70.21,41.01 69.94,40.75 69.94,40.57 70.5,40.01 70.5,39.83 62.19,31.52 62.19,29.47 59.42,26.7 59.42,25.55 v1(58.95,25.09)
  BOTTOM w0.089: U22.AU43 91.23,58.74 v1(90.88,58.39)
  BOTTOM w0.14: v1(58.95,25.09) 58.54,25.09 56.27,27.35 JDIM1.37
M_A_DQ29: length 62.8
  IN3 w0.089: v1(91.59,60.83) 91.2,61.21 86.19,61.21 85.43,60.45 83.37,60.45 83.13,60.69
  IN3 w0.127: 83.13,60.69 82.87,60.69 79.85,60.69 78.38,59.22 78.14,59.22 71.06,52.14 71.06,45.94 62.47,37.35 62.47,36.04 57.31,30.88 57.31,29.34 54.9,26.92 54.9,25.52 v1(54.45,25.07)
  BOTTOM w0.089: U22.AN41 91.95,60.47 v1(91.59,60.83)
  BOTTOM w0.14: JDIM1.25 53.27,26.25 54.45,25.07 v1(54.45,25.07)
M_A_DQ30: length 61.5
  IN3 w0.089: 83.2,61.07 83.56,60.71 84.19,60.71 84.87,61.39 91.74,61.39 v1(92.3,60.83)
  IN3 w0.127: v1(54.45,26.5) 54.15,26.5 53.91,26.74 53.91,27.38 56.22,29.69 56.22,30.61 61.98,36.37 61.98,37.41 70.68,46.1 70.68,52.3 78.11,59.73 78.38,59.73 79.72,61.07 83.2,61.07
  BOTTOM w0.089: v1(92.3,60.83) 92.66,60.47 U22.AN39
  BOTTOM w0.102: v1(54.45,26.5) 54.27,26.67 JDIM1.29
M_A_DQ31: length 65.4
  IN3 w0.089: 83.77,58.05 84.19,58.05 84.4,58.26 85.4,58.26 87.11,59.96 88.76,59.96 89.23,59.49 89.23,58.97 89.82,58.39 v1(90.17,58.39)
  IN3 w0.127: 83.77,58.05 82.4,58.05 81.01,56.66 81.01,56.26 78.78,54.03 78.6,54.03 78.11,54.52 77.85,54.52 77.66,54.34 77.66,54.07 78.15,53.58 78.15,53.4 77.88,53.13 77.7,53.13 77.22,53.61 76.96,53.61 76.78,53.42 76.78,53.16 77.25,52.68 77.25,52.5 76.98,52.24 76.8,52.24 76.33,52.71 76.06,52.71 75.88,52.53 75.88,52.26 76.35,51.79 76.35,51.61 76.08,51.34 75.91,51.34 75.42,51.83 75.15,51.83 74.97,51.64 74.97,51.38 75.46,50.89 75.46,50.71 75.02,50.27 75.02,43.74 62.69,31.42 62.69,29.44 59.8,26.54 59.8,24.36 v1(58.95,23.51)
  BOTTOM w0.089: v1(90.17,58.39) 90.52,58.74 U22.AU44
  BOTTOM w0.14: v1(58.95,23.51) 58.93,23.51 56.53,21.11 JDIM1.38
M_A_DQ32: length 42.5
  IN3 w0.089: v1(94.98,57.25) 94.98,57.05 94.19,56.26 94.19,54.37 94.05,54.23 94.05,52.57 94.29,52.32 94.29,51.35 94.67,50.98 94.67,50.49
  IN3 w0.127: v1(92.82,21.75) 93.96,22.89 93.96,27.16 95.82,29.02 95.82,32.47 96.56,33.21 96.56,40.52 96.93,40.9 96.93,46.33 94.79,48.47 94.79,50.38 94.67,50.49
  BOTTOM w0.089: U22.BA35 94.62,56.9 v1(94.98,57.25)
  BOTTOM w0.14: v1(92.82,21.75) 92.98,21.92 93.69,21.92 94.53,21.08 JDIM1.182
M_A_DQ33: length 41.7
  IN3 w0.089: 95.09,50.58 95.09,51.93 94.22,52.8 94.22,54.15 94.37,54.3 94.37,56.04 95.41,57.07 95.41,57.55 95.82,57.96 v1(95.93,57.96)
  IN3 w0.127: v1(94.89,25.24) 94.34,25.79 94.34,27 96.2,28.86 96.2,31.15 96.32,31.28 96.79,31.28 96.94,31.43 96.94,31.64 96.79,31.79 96.36,31.79 96.2,31.95 96.2,32.17 96.36,32.33 96.81,32.33 96.94,32.47 96.94,40.37 97.31,40.74 97.31,46.49 95.17,48.63 95.17,50.51 95.09,50.58
  BOTTOM w0.089: U22.AY33 95.58,57.61 v1(95.93,57.96)
  BOTTOM w0.14: JDIM1.187 95.78,26.12 v1(94.89,25.24)
M_A_DQ34: length 41.4
  IN3 w0.089: v1(95.93,57.25) 95.84,57.25 94.55,55.96 94.55,54.22 94.4,54.08 94.4,52.96 95.33,52.03 95.33,50.85
  IN3 w0.127: 95.33,50.85 95.55,50.63 95.55,48.79 97.92,46.42 97.92,35.46 97.32,34.85 97.32,31.31 97.48,31.15 98.15,31.15 98.28,31.03 98.28,30.77 98.15,30.65 96.69,30.65 96.58,30.53 96.58,30.28 96.72,30.14 98.01,30.14 98.15,30 98.15,29.77 98.01,29.63 96.8,29.63 96.65,29.49 96.65,28.78 94.88,27 v1(94.88,26.51)
  BOTTOM w0.089: v1(95.93,57.25) 95.58,56.9 U22.BA33
  BOTTOM w0.14: v1(94.88,26.51) 94.78,26.62 JDIM1.183
M_A_DQ35: length 43.6
  IN3 w0.089: v1(94.98,57.96) 94.55,57.53 94.55,56.88 94.01,56.35 94.01,54.45 93.87,54.3 93.87,52.44 94.1,52.21 94.1,51.2 94.32,50.98 94.32,50.37
  IN3 w0.127: v1(92.83,23.18) 93.05,22.96 93.35,22.96 93.58,23.19 93.58,27.32 95.43,29.17 95.43,32.62 96.18,33.37 96.18,40.68 96.55,41.06 96.55,46.17 94.41,48.32 94.41,50.28 94.32,50.37
  BOTTOM w0.089: U22.AY35 94.62,57.61 v1(94.98,57.96)
  BOTTOM w0.14: v1(92.83,23.18) 94.73,21.28 95.21,21.28 95.53,20.96 JDIM1.186
M_A_DQ36: length 43.4
  IN3 w0.089: v1(93.47,57.25) 93.3,57.08 93.3,54.74 93.16,54.6 93.16,53.14 92.49,52.48 92.49,51.56 92.7,51.34 92.7,49.55
  IN3 w0.127: v1(91.46,25.15) 91.02,25.59 91.02,27.16 92.71,28.86 92.71,29.04 92.4,29.35 92.4,29.53 92.58,29.71 92.76,29.71 93.07,29.4 93.25,29.4 93.73,29.88 93.73,30.06 93.61,30.19 92.69,30.19 92.56,30.31 92.56,30.57 92.69,30.7 93.61,30.7 93.73,30.82 93.73,31.08 93.61,31.2 92.72,31.2 92.59,31.33 92.59,31.58 92.72,31.71 93.57,31.71 93.73,31.88 93.73,46.28 92.7,47.3 92.7,49.55
  BOTTOM w0.089: U22.BA37 93.82,56.9 v1(93.47,57.25)
  BOTTOM w0.14: JDIM1.173 92.28,25.96 v1(91.46,25.15)
M_A_DQ37: length 43.4
  IN3 w0.089: v1(93.47,57.96) 93.87,57.56 93.87,57.03 93.48,56.64 93.48,54.67 93.33,54.52 93.33,51.62 93.08,51.37 93.08,50.16
  IN3 w0.127: 93.08,50.16 93.08,47.46 94.11,46.43 94.11,45.92 94.24,45.79 94.63,45.79 94.77,45.64 94.77,45.43 94.63,45.28 94.24,45.28 94.11,45.16 94.11,44.9 94.24,44.77 94.63,44.77 94.77,44.63 94.77,44.42 94.11,43.75 94.11,39.83 94.77,39.17 94.77,38.91 94.65,38.78 94.24,38.78 94.11,38.66 94.11,38.4 94.24,38.28 94.65,38.28 94.77,38.15 94.77,37.9 94.65,37.77 94.24,37.77 94.11,37.64 94.11,37.39 94.24,37.26 94.65,37.26 94.77,37.13 94.77,36.88 94.65,36.75 94.24,36.75 94.11,36.63 94.11,36.37 94.24,36.24 94.65,36.24 94.77,36.12 94.77,35.86 94.65,35.74 94.24,35.74 94.11,35.61 94.11,35.36 94.24,35.23 94.65,35.23 94.77,35.1 94.77,34.85 94.65,34.72 94.24,34.72 94.11,34.59 94.11,34.34 94.24,34.21 94.65,34.21 94.77,34.09 94.77,33.83 94.65,33.7 94.24,33.7 94.11,33.58 94.11,29.72 91.46,27.07 v1(91.46,26.57)
  BOTTOM w0.089: U22.AY37 93.82,57.61 v1(93.47,57.96)
  BOTTOM w0.14: JDIM1.169 91.28,26.76 v1(91.46,26.57)
M_A_DQ38: length 42.4
  IN3 w0.089: v1(92.52,57.95) 92.95,57.51 92.95,57.17 93.12,57 93.12,54.81 92.98,54.67 92.98,53.35 92.28,52.65 92.28,51.43 92.41,51.31 92.41,49.58
  IN3 w0.127: 92.41,49.58 92.32,49.49 92.32,47.1 92.65,46.77 92.65,46.59 92.42,46.35 92.42,46.14 92.57,45.99 92.78,45.99 93.01,46.23 93.19,46.23 93.35,46.07 93.35,32.88 91.95,31.49 91.95,28.64 90.64,27.32 90.64,23.77 v1(91.46,22.94)
  BOTTOM w0.089: v1(92.52,57.95) 92.86,57.61 U22.AY39
  BOTTOM w0.14: v1(91.46,22.94) 92.35,22.05 92.35,21.28 92.53,21.11 JDIM1.174
M_A_DQ39: length 40.6
  IN3 w0.089: 92.14,49.74 92.14,51.27 92.03,51.38 92.03,52.75 92.8,53.52 92.8,54.74 92.9,54.85 92.91,54.85 92.95,54.89 92.95,56.81 v1(92.52,57.24)
  IN3 w0.127: 92.14,49.74 91.94,49.54 91.94,40.9 92.97,39.88 92.97,33.04 91.57,31.64 91.57,28.8 90.25,27.48 90.25,23.61 90.9,22.97 90.9,22.15 v1(91.46,21.59)
  BOTTOM w0.089: v1(92.52,57.24) 92.86,56.9 U22.BA39
  BOTTOM w0.14: JDIM1.170 91.53,21.52 v1(91.46,21.59)
M_A_DQ40: length 40
  IN1 w0.089: v1(92.54,43.74) 91.45,42.64 91.45,40.17 90.76,39.48 90.76,39.29 90.89,39.16 91.29,39.16 91.42,39.03 91.42,38.84 91.29,38.71 90.94,38.71 90.76,38.54 90.76,35.96 94.99,31.74 94.99,31.05 98.32,27.72 98.32,24.1 v1(98.9,23.51)
  BOTTOM w0.089: 93.92,49.46 93.92,52.16 93.9,52.23 93.9,52.43 94.04,52.61 U22.BJ36
  BOTTOM w0.14: JDIM1.208 101.03,20.98 99.62,22.39 99.62,22.8 v1(98.9,23.51) ; 93.92,49.46 93.55,49.09 93.55,46.81 92.08,45.34 92.08,43.95 92.28,43.74 v1(92.54,43.74)
M_A_DQ41: length 39.7
  IN1 w0.089: v1(98.92,26.27) 99.23,26.27 99.37,26.41 99.37,27.15 95.33,31.19 95.33,31.88 92.2,35.01 92.2,35.94 92.06,36.08 91.23,36.08 91.1,36.21 91.1,36.39 91.23,36.52 92.07,36.52 92.2,36.65 92.2,36.84 92.07,36.97 91.23,36.97 91.1,37.1 91.1,37.28 91.23,37.41 92.07,37.41 92.2,37.54 92.2,37.72 92.07,37.85 91.23,37.85 91.1,37.98 91.1,38.17 91.23,38.3 92.05,38.3 92.2,38.44 92.2,39.25 91.88,39.57 91.88,42.16 92.18,42.47 v1(92.54,42.47)
  BOTTOM w0.089: U22.BK37 93.72,52.65 93.72,52.15 93.74,52.14 93.74,51.08 93.68,51.03 93.68,49.58
  BOTTOM w0.14: JDIM1.203 99.78,27.02 99.02,26.27 v1(98.92,26.27) ; v1(92.54,42.47) 92.41,42.47 91.68,43.2 91.68,45.5 93.28,47.1 93.28,49.18 93.68,49.58
M_A_DQ42: length 41.3
  IN1 w0.089: v1(98.91,24.9) 99.73,25.72 99.73,27.28 97.53,29.47 97.53,29.6 98,30.06 98,30.25 97.87,30.38 97.69,30.38 97.22,29.91 97.09,29.91 96.91,30.1 96.91,30.23 97.37,30.69 97.37,30.88 97.24,31.01 97.06,31.01 96.59,30.54 96.47,30.54 96.28,30.73 96.28,30.86 96.73,31.31 96.73,31.49 96.6,31.62 96.42,31.62 95.96,31.17 95.84,31.17 95.68,31.33 95.68,32.02 92.54,35.16 v1(92.54,41.2)
  BOTTOM w0.089: U22.BJ35 94.41,52.82 94.39,52.79 94.35,52.72 94.34,52.6 94.38,52.51 94.43,52.45 94.45,52.38 94.45,52.2 94.31,52.06 94.31,51.21 94.37,51.15 94.37,49.15
  BOTTOM w0.14: v1(92.54,41.2) 92.64,41.2 92.99,41.55 92.99,45.14 94.08,46.23 94.08,48.86 94.37,49.15 ; JDIM1.207 100.78,27.18 100.31,26.72 100.31,26.33 98.88,24.9 v1(98.91,24.9)
M_A_DQ43: length 40.1
  IN1 w0.089: v1(92.54,45.01) 90.99,43.46 90.99,41.98 90.85,41.85 90.5,41.85 90.37,41.72 90.37,41.53 90.5,41.4 90.88,41.4 91.01,41.27 91.01,41.09 90.88,40.96 90.48,40.96 90.35,40.83 90.35,40.64 90.48,40.51 90.86,40.51 90.99,40.38 90.99,40.2 90.86,40.07 90.43,40.07 90.34,39.98 90.34,35.88 94.65,31.57 94.65,30.9 97.97,27.58 97.97,22.98 v1(98.9,22.05)
  BOTTOM w0.089: U22.BL36 94.13,52.29 94.13,49.29
  BOTTOM w0.14: 94.13,49.29 93.82,48.98 93.82,46.52 92.54,45.24 v1(92.54,45.01) ; JDIM1.204 100.03,20.93 98.91,22.05 v1(98.9,22.05)
M_A_DQ44: length 39.5
  IN1 w0.089: v1(96.6,25.41) 95.98,26.03 95.98,26.66 89.62,33.01 89.62,33.14 90.04,33.56 90.04,33.69 89.85,33.87 89.73,33.87 89.31,33.46 89.13,33.46 89,33.59 89,33.77 89.41,34.19 89.41,34.31 89.22,34.5 89.1,34.5 88.69,34.1 88.51,34.1 88.38,34.23 88.38,34.41 88.78,34.82 88.78,34.94 88.48,35.24 v1(88.48,40.98)
  BOTTOM w0.089: U22.BJ39 92.6,52.82 92.58,52.79 92.55,52.72 92.54,52.6 92.58,52.51 92.63,52.45 92.64,52.38 92.64,52.2 92.46,52.02 92.46,51.33 92.51,51.28 92.51,50.21 91.97,49.67 91.97,49.24
  BOTTOM w0.14: v1(88.48,40.98) 88.59,40.98 89.85,42.24 89.85,45.51 91.97,47.64 91.97,49.24 ; JDIM1.195 97.78,26.58 v1(96.6,25.41)
M_A_DQ45: length 38.6
  IN1 w0.089: v1(88.48,42.25) 88.18,42.25 88.04,42.11 88.04,34.02 95.64,26.41 95.64,22.73 95.43,22.53 v1(95.04,22.53)
  BOTTOM w0.089: U22.BL40 92.27,52.24 92.27,50.31 91.7,49.73 91.7,49.25 91.7,49.25
  BOTTOM w0.14: v1(88.48,42.25) 88.61,42.25 89.45,43.09 89.45,45.68 91.7,47.93 91.7,49.25 ; JDIM1.190 96.53,21.11 95.11,22.53 v1(95.04,22.53)
M_A_DQ46: length 39.3
  IN1 w0.089: v1(88.48,43.52) 87.69,42.73 87.69,33.87 93.73,27.83 93.73,25.07 94.94,23.86 v1(95.07,23.86)
  BOTTOM w0.089: U22.BJ40 92.23,52.61 92.11,52.44 92.1,52.43 92.1,50.46 91.43,49.79 91.43,49.22
  BOTTOM w0.14: v1(95.07,23.86) 95.73,23.2 95.73,22.26 96.51,21.48 96.96,21.48 97.53,20.92 JDIM1.194 ; v1(88.48,43.52) 88.66,43.52 89.06,43.91 89.06,45.84 91.43,48.22 91.43,49.22
M_A_DQ47: length 37.8
  IN1 w0.089: v1(96.6,26.83) 92.84,30.59 92.84,30.73 93.15,31.03 93.15,31.22 93.02,31.35 92.83,31.35 92.42,30.93 92.24,30.93 92.11,31.06 92.11,31.25 92.53,31.67 92.53,31.83 92.39,31.98 92.21,31.98 91.77,31.54 91.58,31.54 91.45,31.67 91.45,31.85 91.85,32.25 91.85,32.44 91.72,32.57 91.54,32.57 91.15,32.18 90.97,32.18 90.84,32.31 90.84,32.49 91.2,32.85 91.2,33.04 91.07,33.17 90.88,33.17 90.51,32.8 90.33,32.8 90.2,32.93 90.2,33.11 90.62,33.54 90.62,33.66 89.01,35.28 89.01,44.26 v1(88.48,44.79)
  BOTTOM w0.089: 91.17,49.19 91.17,49.88 91.92,50.63 U22.BK41
  BOTTOM w0.14: v1(96.6,26.83) 96.78,27 JDIM1.191 ; v1(88.48,44.79) 88.48,45.82 91.17,48.51 91.17,49.19
M_A_DQ48: length 40.6
  IN3 w0.127: v1(96.89,55.12) 97.9,54.11 97.9,53.29 98.46,52.73 99.6,52.73 100.34,51.99 100.34,49.32 103.09,46.56 103.09,32.6 103.32,32.37 104.44,32.37 104.65,32.16 104.65,31.9 104.49,31.74 103.22,31.74 103.09,31.61 103.09,31.25 103.25,31.1 104.59,31.1 104.85,30.85 104.85,26.11 v1(104.39,25.65)
  BOTTOM w0.089: v1(96.89,55.12) 97.24,55.47 U22.BD29
  BOTTOM w0.14: v1(104.39,25.65) 105.28,26.54 JDIM1.225
M_A_DQ49: length 40.8
  IN3 w0.127: v1(104.39,22.81) 103.94,23.26 103.94,29.13 103.68,29.39 103.68,29.57 104.1,29.99 104.1,30.27 103.93,30.44 103.65,30.44 103.23,30.02 103.05,30.02 102.71,30.36 102.71,46.41 99.98,49.14 99.98,51.81 99.57,52.22 98.41,52.22 97.52,53.11 97.52,53.79 v1(96.9,54.41)
  BOTTOM w0.089: v1(96.9,54.41) 97.25,54.76 U22.BF29
  BOTTOM w0.14: JDIM1.228 106.03,21.17 v1(104.39,22.81)
M_A_DQ50: length 40.6
  IN3 w0.127: v1(96.89,53.7) 97.12,53.47 97.12,52.97 99.12,50.97 99.12,49.46 102.33,46.25 102.33,29.1 102.47,28.96 103.37,28.96 103.56,28.78 103.56,28.47 103.42,28.33 102.49,28.33 102.33,28.17 102.33,27.89 102.5,27.72 103.32,27.72 103.51,27.53 103.51,21.64 103.79,21.36 v1(104.39,21.36)
  BOTTOM w0.089: U22.BH29 97.25,54.05 v1(96.89,53.7)
  BOTTOM w0.14: JDIM1.224 105.03,20.95 104.62,21.36 v1(104.39,21.36)
M_A_DQ51: length 41.6
  IN3 w0.089: v1(94.98,55.12) 95.37,54.73 95.37,53.1 96.15,52.32 96.15,52.2
  IN3 w0.127: 96.15,52.2 96.84,51.5 96.84,49.33 100.59,45.58 100.59,42.89 100.34,42.63 99.84,42.63 99.65,42.45 99.65,42.18 99.84,42 100.38,42 100.57,41.81 100.57,41.55 100.38,41.36 99.86,41.36 99.68,41.18 99.68,40.91 99.86,40.73 100.4,40.73 100.59,40.54 100.59,40.28 100.4,40.09 99.88,40.09 99.68,39.89 99.68,34.9 100.27,34.3 100.27,25.52 v1(101.11,24.69)
  BOTTOM w0.089: v1(94.98,55.12) 95.34,54.76 U22.BF33
  BOTTOM w0.14: JDIM1.215 102.78,27.35 102.32,26.9 102.32,25.9 v1(101.11,24.69)
M_A_DQ52: length 41.5
  IN3 w0.127: v1(96.89,55.83) 96.89,55.83 98.24,54.47 98.24,53.53 98.63,53.14 99.9,53.14 101.25,51.79 101.25,48.94 103.47,46.72 103.47,33.95 105.23,32.19 105.23,25.07 v1(104.39,24.23)
  BOTTOM w0.089: U22.BC29 97.24,56.19 v1(96.89,55.83)
  BOTTOM w0.14: v1(104.39,24.23) 106.28,26.12 JDIM1.229
M_A_DQ53: length 41.2
  IN3 w0.089: 96.35,52.47 95.54,53.27 95.54,55.26 v1(94.98,55.83)
  IN3 w0.127: v1(101.11,26.11) 100.65,26.56 100.65,27.19 101,27.53 101,34.95 100.81,35.13 100.29,35.13 100.11,35.32 100.11,35.58 100.29,35.77 100.81,35.77 101,35.95 101,36.22 100.81,36.4 100.29,36.4 100.11,36.59 100.11,36.85 100.29,37.04 100.81,37.04 101,37.22 101,37.49 100.81,37.67 100.29,37.67 100.11,37.86 100.11,38.12 100.29,38.31 100.81,38.31 101,38.49 101,38.76 100.81,38.94 100.32,38.94 100.13,39.13 100.13,39.39 100.32,39.58 100.87,39.58 101,39.7 101,45.71 97.23,49.49 97.23,51.59 96.35,52.47
  BOTTOM w0.089: U22.BD33 95.34,55.47 v1(94.98,55.83)
  BOTTOM w0.14: v1(101.11,26.11) 101.51,26.11 101.78,26.38 JDIM1.211
M_A_DQ54: length 41.9
  IN3 w0.089: v1(94.98,54.41) 94.58,54.01 94.58,53.19 95.56,52.21 95.56,51.11
  IN3 w0.127: v1(101.11,21.79) 100.54,21.79 99.42,22.91 99.42,29.66 98.82,30.26 98.82,32.47 98.69,32.6 97.98,32.6 97.86,32.73 97.86,33.11 97.98,33.23 98.69,33.23 98.82,33.36 98.82,33.74 98.69,33.87 97.98,33.87 97.86,34 97.86,34.38 97.98,34.5 98.69,34.5 98.82,34.63 98.82,46.27 96.08,49.01 96.08,50.59 95.56,51.11
  BOTTOM w0.089: U22.BF35 94.62,54.76 v1(94.98,54.41)
  BOTTOM w0.14: JDIM1.212 102.03,21.07 101.31,21.79 v1(101.11,21.79)
M_A_DQ55: length 40.6
  IN3 w0.089: v1(94.98,53.7) 94.98,53.12 95.54,52.56 95.87,52.23 95.87,52.04 95.89,52.02
  IN3 w0.127: 95.89,52.02 96.46,51.45 96.46,49.17 99.2,46.43 99.2,45.19 99.33,45.06 100,45.06 100.18,44.87 100.18,44.61 100,44.42 99.46,44.42 99.27,44.24 99.27,43.97 99.46,43.79 100.02,43.79 100.21,43.6 100.21,43.34 100.02,43.15 99.33,43.15 99.2,43.03 99.2,30.42 99.83,29.79 99.83,24.51 v1(101.09,23.25)
  BOTTOM w0.089: v1(94.98,53.7) 94.62,54.05 U22.BH35
  BOTTOM w0.14: JDIM1.216 103.03,20.95 102.06,21.91 102.06,22.3 101.12,23.25 v1(101.09,23.25)
M_A_DQ56: length 38.5
  IN1 w0.089: v1(106.84,21.61) 105.32,23.14 105.32,26.74 100.4,31.66 100.4,32.44 95,37.84 95,39.72 v1(94.77,39.95)
  BOTTOM w0.089: U22.BL34 95.07,51.74 95.08,51.73 95.08,51.22 94.75,50.89 94.75,48.99
  BOTTOM w0.14: v1(106.84,21.61) 107.03,21.43 JDIM1.232 ; 94.75,48.99 94.63,48.87 94.63,45.84 93.54,44.75 93.54,41.19 94.77,39.95 v1(94.77,39.95)
M_A_DQ57: length 39.6
  IN1 w0.089: v1(110.69,25.37) 111.08,25.75 111.08,27.14 110.41,27.81 109.61,27.81 108.97,28.45 108.78,28.45 108.33,28 108.15,28 108.02,28.13 108.02,28.32 108.45,28.75 108.45,28.94 108.32,29.07 108.14,29.07 107.7,28.63 107.52,28.63 107.39,28.76 107.39,28.95 107.83,29.39 107.83,29.59 97.46,39.95 v1(97.46,40.02)
  BOTTOM w0.089: 97.03,50.11 97.03,50.55 97.01,50.57 97.01,52.21 U22.BL30
  BOTTOM w0.14: v1(97.46,40.02) 97.03,40.46 97.03,44.27 97.03,44.27 97.03,50.11 ; JDIM1.249 111.28,25.95 v1(110.69,25.37)
M_A_DQ58: length 40.6
  IN1 w0.089: v1(98.38,39.92) 98.38,39.53 109.75,28.15 110.55,28.15 111.46,27.25 111.46,24.86 111.1,24.5 111.1,23.1 110.95,22.96 110.81,22.96 v1(110.7,23.07)
  BOTTOM w0.089: 97.29,50.11 97.29,50.54 97.2,50.63 97.2,52.35 97.19,52.36 97.09,52.51 97.05,52.6 97.06,52.72 97.09,52.79 97.14,52.85 97.24,53.02 U22.BJ29
  BOTTOM w0.14: v1(98.38,39.92) 98.37,39.92 97.42,40.87 97.42,44.43 97.29,44.56 97.29,50.11 ; v1(110.7,23.07) 111.53,22.25 JDIM1.250
M_A_DQ59: length 39.7
  IN1 w0.089: v1(98.38,41.19) 98.49,41.19 98.85,40.83 98.85,39.54 109.89,28.5 110.7,28.5 111.87,27.32 111.87,24.56 111.44,24.13 111.44,22.39 v1(110.73,21.68)
  BOTTOM w0.089: 97.56,50.14 97.56,50.59 97.38,50.77 97.38,52.6 U22.BK29
  BOTTOM w0.14: v1(110.73,21.68) 110.53,21.47 JDIM1.246 ; 97.56,50.14 97.56,44.85 97.82,44.6 97.82,41.75 v1(98.38,41.19)
M_A_DQ60: length 39.6
  IN1 w0.089: v1(107.15,24.48) 107.63,24.96 107.63,26.01 103.41,30.22 103.41,31.58 99.65,35.34 98.95,35.34 96.09,38.2 96.09,40.98 95.52,41.56 95.52,43.2 94.95,43.76 v1(94.77,43.76)
  BOTTOM w0.089: 95.49,48.49 95.49,50.67 95.61,50.8 95.61,51.99 95.7,52.08 95.7,52.33 95.7,52.34 95.7,52.39 arc(95.73,52.44) 95.75,52.5 arc(95.76,52.52) 95.77,52.54 arc(95.78,52.54) 95.78,52.55 arc(95.79,52.59) 95.8,52.63 95.8,52.65 arc(95.78,52.73) 95.75,52.8 95.75,52.81 95.72,52.84 arc(95.72,52.84) 95.71,52.85 95.53,53.03 U22.BJ33
  BOTTOM w0.14: v1(107.15,24.48) 108.28,25.6 JDIM1.237 ; 95.49,48.49 95.43,48.43 95.43,44.95 94.72,44.24 94.72,43.82 v1(94.77,43.76)
M_A_DQ61: length 38.5
  IN1 w0.089: v1(107.13,25.9) 102.57,30.46 102.57,30.86 103.02,31.3 103.02,31.49 102.89,31.62 102.7,31.62 102.22,31.14 102.04,31.14 101.91,31.27 101.91,31.45 102.36,31.9 102.36,32.09 102.23,32.22 102.04,32.22 101.6,31.77 101.35,31.77 101.23,31.9 101.23,33.28 99.51,35 98.81,35 95.71,38.1 95.71,40.87 95.17,41.41 95.17,42.09 v1(94.77,42.49)
  BOTTOM w0.089: U22.BK33 95.53,52.4 95.52,52.39 95.52,52.15 95.44,52.06 95.44,51 95.21,50.77 95.21,48.64
  BOTTOM w0.14: JDIM1.233 107.28,26.05 v1(107.13,25.9) ; v1(94.77,42.49) 94.62,42.49 94.32,42.79 94.32,44.42 95.16,45.26 95.16,48.59 95.21,48.64
M_A_DQ62: length 39.4
  IN1 w0.089: v1(107.16,23.11) 105.72,24.55 105.72,26.82 100.74,31.8 100.74,32.58 95.36,37.97 95.36,40.64 v1(94.77,41.22)
  BOTTOM w0.089: U22.BJ34 95.3,52.49 95.35,52.45 95.35,52.27 95.3,52.18 95.26,52.14 95.26,51.15 94.98,50.87 94.98,48.79
  BOTTOM w0.14: 94.98,48.79 94.89,48.71 94.89,45.55 93.93,44.59 93.93,42.06 94.77,41.22 v1(94.77,41.22) ; JDIM1.236 108.03,22.24 v1(107.16,23.11)
M_A_DQ63: length 40.1
  IN1 w0.089: v1(97.46,38.75) 99.44,36.78 99.99,36.78 104.64,32.12 104.64,30.76 104.79,30.62 104.91,30.62 105.41,31.12 105.59,31.12 105.72,30.99 105.72,30.8 105.25,30.33 105.25,30.15 105.39,30.02 105.57,30.02 106.05,30.5 106.23,30.5 106.36,30.37 106.36,30.19 105.88,29.7 105.88,29.52 106.01,29.39 106.2,29.39 106.67,29.86 106.85,29.86 106.98,29.73 106.98,29.54 106.48,29.05 106.48,28.92 108,27.4 110.07,27.4 v1(110.66,26.82)
  BOTTOM w0.089: 96.76,50.21 96.76,50.68 96.83,50.75 96.83,51.99 96.61,52.22 96.61,52.43 96.62,52.45 96.68,52.53 96.88,52.73 U22.BJ30
  BOTTOM w0.14: JDIM1.245 110.28,27.2 v1(110.66,26.82) ; v1(97.46,38.75) 97.46,38.75 96.64,39.58 96.64,50.09 96.76,50.21
