# Allegro board Quanta ZHE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
H_PROCHOT#: length 257.9
  TOP w0.14: PR107.2 v1(149.13,9.83)
  IN1 w0.089: v1(26.18,36.86) 26.11,36.79 26.11,30.86 27.06,29.9 27.06,27.1 27.23,26.94 27.23,18.72 32.85,13.1 35.28,13.1 35.85,12.54 39.05,12.54 41.29,10.3 47.12,10.3 47.72,10.9 58.25,10.9 60.16,9 65.67,9 66.26,8.41 82.28,8.41 83.37,9.49 119.66,9.49 121.55,11.38 132.9,11.38 134.4,9.87 135.38,9.87 135.76,9.49 136.77,9.49 137.15,9.87 137.74,9.87 137.88,9.73 137.88,8.54 139.03,7.4 146.78,7.4 149.13,9.74 v1(149.13,9.83)
  IN3 w0.127: v1(47.61,60.98) 47.61,60.91 47.4,60.7 46.09,60.7 45.82,60.42 45.82,60.09 44.19,58.47 33.27,58.47 33.08,58.28 32.91,58.28 32.66,58.02 28.8,58.02 25.41,54.63 25.41,47.64 23.15,45.38 23.15,43.37 23.4,43.11 23.4,41.02 26.18,38.24 v1(26.18,36.86)
  BOTTOM w0.079: U22.J54 86.07,71.32 85.6,71.78 85.26,71.78
  BOTTOM w0.089: 83.73,71.78 85.26,71.78
  BOTTOM w0.14: PR191.2 38.7,63.88 38.7,63.87 39.22,63.35 42.18,63.35 43.26,64.44 PR189.2 45.74,64.07 45.88,63.93 46.54,63.93 46.79,63.68 46.79,63.06 PR202.2 46.52,62.07 v1(47.61,60.98) 48.09,60.98 48.64,60.43 48.64,58.89 50.39,57.14 56.24,57.14 58.67,59.57 59.04,59.57 60.99,61.52 61.21,61.52 v1(61.61,61.92) 62.25,62.55 63.3,62.55 64.11,63.36 64.72,63.36 67.38,66.02 69.23,66.02 69.62,66.41 71.11,66.41 71.42,66.1 R487.1 72.18,66.1 72.61,66.52 73.27,66.52 74.15,67.4 76.56,67.4 80.12,70.96 81.88,70.96 82.23,70.61 82.56,70.61 83.73,71.78 ; v1(26.18,36.86) 25.69,36.36 Q34.3
HDA_BCLK_R: length 6.3
  BOTTOM w0.089: R425.1 102.78,79.5 v1(102.32,79.04) 102.2,78.93 102.2,77.58 101.12,76.51 101.12,76.5 100.44,75.82 100.44,75.01 U22.A22
HDA_RST#_R: length 8.1
  BOTTOM w0.089: 101.36,75.91 101.1,75.65 101.1,75.24 101.11,75.23 101.11,74.87 101.13,74.86 101.23,74.72 101.23,74.59 101.13,74.45 100.94,74.26 U22.C21
  BOTTOM w0.14: 101.36,75.91 101.62,75.91 103.67,77.96 103.67,78.57 104.81,79.7 R427.2
HDA_SDO_R: length 7.4
  BOTTOM w0.089: R426.1 103.79,79.75 v1(103.54,79.5) 102.38,78.34 102.38,77.51 100.62,75.74 100.62,75.22 100.66,75.17 100.76,75.08 100.76,74.88 100.67,74.76 100.64,74.61 U22.C22
HDA_SYNC_R: length 9.6
  BOTTOM w0.089: U22.C23 100.03,74.26 100.22,74.45 100.32,74.59 100.32,74.72 100.22,74.86 100.21,74.87 100.21,75.84 101.89,77.52 101.89,80.21 v1(101.96,80.29)
  BOTTOM w0.14: R414.1 102.78,81.82 102.27,81.31 102.27,80.59 v1(101.96,80.29)
HDMI_5V:
  vias: v1(119.67,95.68) v1(120.45,95.81) v1(120.94,95.35)
HDMI_DDCCLK_SW: length 37.9
  IN1 w0.089: v1(89.19,78.71) 89.77,79.3 92.69,79.3 92.78,79.21 93.18,79.21 95.16,77.23 100.18,77.23 101.45,78.5 101.45,79.09 102.58,80.22 113.86,80.22 v1(115.09,81.46)
  BOTTOM w0.089: U22.B43 91.02,74.9 91.29,75.18 91.29,76.1 91.02,76.38
  BOTTOM w0.127: v1(89.19,78.71) 89.24,78.71 89.94,78.01 89.94,77.45 91.02,76.38
  BOTTOM w0.14: R436.1 113.83,79.55 114.57,79.55 114.7,79.68 Q32.4 114.7,81.08 114.71,81.08 v1(115.09,81.46) 115.21,81.57 R419.2
HDMI_DDCDATA_SW: length 42.9
  IN1 w0.089: v1(114.08,77.9) 113.7,77.52 112.55,77.52 111.67,78.41 111.67,79.55 111.34,79.87 103.23,79.87 102.01,78.65 102.01,78.16 100.73,76.88 95.02,76.88 93.04,78.87 92.51,78.87 92.42,78.95 89.99,78.95 89.59,78.55 89.59,78.55 89.35,78.31 89.34,78.31 89.19,78.15 v1(89.19,78.05)
  BOTTOM w0.089: U22.C43 91.02,74.26 90.83,74.45 90.73,74.59 90.73,74.72 90.83,74.86 90.84,74.88 90.84,74.98 91.12,75.25 91.12,75.97 90.99,76.1
  BOTTOM w0.127: 90.99,76.1 89.73,77.36 89.73,77.92 89.59,78.05 v1(89.19,78.05)
  BOTTOM w0.14: v1(114.08,77.9) 114.08,77.89 114.08,77.39 114.22,77.25 114.57,77.25 114.71,77.11 114.71,76.84 114.57,76.7 114.22,76.7 114.08,76.56 114.08,76.24 114.28,76.05 115.61,76.05 115.86,76.3 R454.2 115.99,76.63 115.99,77.32 116,77.32 Q32.1 116,78.66 116.25,78.91 R435.1
HDMI_HPD: length 22.8
  TOP w0.127: v1(118.52,88.31) 118.67,88.17 U6.21
  BOTTOM w0.127: v1(118.52,88.31) 117.89,88.31 117.52,88.69 117.52,92.87 117.96,93.32 119.89,93.32 120.89,92.32 v1(122.46,92.32) EC6.1 123.96,92.98 123.96,93.78 C333.1 126.04,94.67 128.4,97.04 128.4,98.18 127.8,98.79 CN1.19
HDMI_HPD_C: length 24.9
  TOP w0.127: R79.1 117.76,75.11 v1(117.51,74.85) 117.51,74.59 116.87,73.95 113.76,73.95 111.35,76.37 111.35,79.89 111.68,80.23 111.68,82.1 111.88,82.31 111.88,85.4 112.4,85.92 112.4,86.26 113.09,86.94 113.09,86.89 v1(113.11,86.87)
  IN1 w0.089: v1(113.11,86.87) 113.61,86.37 115.18,86.37 v1(115.86,87.04)
  BOTTOM w0.127: R437.2 116.23,87.54 115.86,87.17 v1(115.86,87.04)
HDMI_HPD_DC: length 6.2
  TOP w0.127: U6.40 118.67,79.93 118.59,79.85 v1(118.59,77.32) 118.59,77.05 118.05,76.51 R79.2 R78.1
HDMI_RST#: length 7.3
  TOP w0.127: R60.2 114.85,77.77 v1(115.02,77.77) 115.02,78.11 C39.2 114.97,78.66 115.35,79.04 115.35,80.82 115.55,81.02 115.55,81.57 116.08,82.1 116.08,82.1 116.19,82.21 116.19,82.23 116.28,82.32 U6.35
HDMI_SCLK: length 36.7
  TOP w0.14: v1(124.11,85.36) 124.14,85.39 125,85.39 125.5,84.89 R627.2 ; v1(125.89,95.3) 125.64,95.05 C9.1
  IN3 w0.127: v1(124.11,85.36) 124.11,85.37 124.39,85.65 124.39,91.46 123.48,92.38 123.48,93.65 123.73,93.9 124.49,93.9 v1(125.89,95.3)
  BOTTOM w0.14: R390.2 123.87,89.97 124.39,89.44 124.39,85.65 124.11,85.37 v1(124.11,85.36) 124.41,85.06 124.41,84.89 124.89,84.41 124.89,81.11 124.89,80.78 123.39,79.28 121.83,79.28 121.11,78.56 120.59,78.56 R628.2 ; v1(125.89,95.3) 125.94,95.3 127.89,97.25 127.89,97.97 127.51,98.35 126.55,98.35 CN1.15
HDMI_SCLK_R: length 4.7
  TOP w0.127: v1(126.65,83.62) 126.15,84.11 R627.1
  TOP w0.14: U6.7 123.61,84.32 124.31,83.62 125.01,83.62 125.19,83.8 125.19,83.8 125.51,84.11 R627.1
HDMI_SDATA: length 31.8
  TOP w0.14: C8.1 125,94.67 125.19,94.86 125.19,94.99 125.24,95.04 v1(125.24,95.29) ; v1(123.48,85.36) 123.48,85.15 123.73,84.89 R626.2
  IN3 w0.127: v1(123.48,85.36) 123.48,85.37 123.96,85.85 123.96,91.36 123.1,92.22 123.1,93.81 123.57,94.28 124.33,94.28 125.24,95.19 v1(125.24,95.29)
  BOTTOM w0.14: v1(125.24,95.29) 126.78,96.83 126.78,97.14 126.31,97.6 CN1.16 ; R629.2 120.44,79.03 120.51,78.96 120.94,78.96 121.66,79.68 123.22,79.68 124.49,80.95 124.49,84.25 123.48,85.27 v1(123.48,85.36) 123.48,85.39 124,85.91 124,86.04 124,88.95 R395.2
HDMI_SDATA_R: length 2.4
  TOP w0.14: R626.1 124.49,84.37 123.95,84.37 123.74,84.58 123.3,84.58 123.16,84.72 U6.8
HDMI_SEL#_A1: length 2.6
  TOP w0.127: R42.2 114.81,84.4 v1(115.6,83.62) 115.69,83.52 U6.32
HP-L2: length 28.9
  TOP w0.203: 178.88,22.16 U16.32
  TOP w0.254: v1(178.52,22.93) 178.52,22.53 178.88,22.16
  TOP w0.508: v1(171.23,44.63) 171.98,45.38 L3.1
  IN3 w0.508: v1(178.52,22.93) 178.72,23.14 178.72,23.53 178.87,23.68 178.87,24.74 179.48,25.35 179.48,33.69 177.56,35.62 176.94,35.62 172.17,40.38 172.17,43.69 v1(171.23,44.63)
HP-L3: length 5.6
  TOP w0.508: R215.2 171.98,47.33 172.3,47.01 172.37,47.01 172.76,46.62 R226.1 L3.2 172.76,44.22 C213.2 171.95,44.08 v1(171.23,43.36)
HP-L4: length 5.4
  TOP w0.508: CN8.1 v1(173.64,48.65) 172.85,48.65 C195.2 R215.1
HP-R2: length 33.6
  TOP w0.203: U16.33 178.48,21.89
  TOP w0.254: v1(177.83,23.57) 177.73,23.47 177.73,22.65 v1(177.97,22.41) 178.48,21.89
  TOP w0.508: L1.1 171.98,49.58 171.45,49.05 v1(171.45,49.04)
  IN3 w0.508: v1(171.45,49.04) 171.41,49.04 170.34,47.96 170.34,40.96 176.57,34.73 177.19,34.73 178.59,33.32 178.59,25.73 177.98,25.12 177.98,24.08 177.83,23.93 v1(177.83,23.57)
HP-R3: length 4
  TOP w0.508: L1.2 R203.1 172.76,51.27 C185.2 173.76,51.46 R204.2
HP-R4: length 10.4
  TOP w0.508: R204.1 174.54,50.86 174.91,51.23 176.32,51.23 176.57,50.98 C190.2 176.94,50.6 177.45,51.1 v1(179.99,51.1) 180.75,51.1 182.15,49.7 CN8.2
HP_JD#: length 27.5
  TOP w0.254: R340.2 v1(183.55,15.42) ; v1(183.04,37.13) D16.1 182.19,38.02 182.35,38.18 CN8.6
  IN3 w0.254: v1(183.04,37.13) 181.9,35.99 181.9,25.41 183.55,23.76 183.55,21.89 184.06,21.39 184.06,15.67 183.8,15.42 v1(183.55,15.42)
HWPG: length 33.4
  TOP w0.127: D22.2 D21.2 16.24,26.01 15.91,26.34 15.91,29.51 16.08,29.69 D18.2 ; U14.21 21.92,30.38 21.18,29.64 18.84,29.64 18.58,29.39 R302.1 18.58,28.51 18.22,28.14 v1(17.56,28.14) 17.02,28.14 16.42,28.75 D18.2 ; D18.2 16.42,30.49 16.25,30.65 15.87,30.65 15.34,31.18 15.34,37.2 16.36,38.23 D14.2 D11.2 D10.2 D9.2 D8.2
HWPG_1.2VSUS: length 146.4
  TOP w0.127: D18.1 16.42,26.59 16.7,26.31 v1(17.94,26.31) 19,26.31 19.59,25.72 19.59,24.17 19.91,23.84 22.3,23.84 23.27,24.81 23.27,25.14 24.93,26.8 30.11,26.8 31.76,28.45 v1(32.19,28.45)
  IN1 w0.089: v1(32.19,28.45) 34.12,28.45 35.15,27.42 41.53,27.42 42.71,26.24 42.71,21.15 48.9,14.95 57.82,14.95 60.51,12.26 75.53,12.26 76.17,12.9 86,12.9 90.45,17.34 98.26,17.34 98.85,17.94 111.38,17.94 113.81,20.38 115.91,20.38 118.3,22.77 124.72,22.77 129.12,27.18 136.55,27.18 137.13,26.59 v1(139.48,26.59)
  BOTTOM w0.127: PR245.2 PR244.2 140.25,26.59 v1(139.48,26.59)
HWPG_1.05V: length 297
  TOP w0.127: PR9.2 PR7.2 149.76,78.4 150.15,78.79 v1(151.67,78.79) ; v1(52.31,53.85) 51.72,54.43 51.72,54.79 50.7,55.81 44.11,55.81 43.51,56.41 42.47,56.41 38.98,52.92 38.98,52.43 37.82,51.27 37.06,51.27 34.91,49.12 34.07,49.12 32.86,47.92 27.94,47.92 25.31,50.56 21.07,50.56 19.37,48.85 19.37,46.91 19.97,46.3 19.97,44.5 19.68,44.21 19.68,41.01 D11.1
  IN3 w0.127: v1(52.31,53.85) 52.31,53.16 53.4,52.07 53.4,49.05 52.41,48.06 52.41,44.75 53.73,43.43 53.73,42.4 49.18,37.85 48.69,37.85 47.15,36.31 47.15,33.99 46.32,33.16 46.32,26 45.01,24.68 45.01,23.44 47.26,21.19 47.26,16.93 49.17,15.03 54.44,15.03 57.03,12.43 73.34,12.43 75.19,14.29 85.64,14.29 87.22,15.86 92.99,15.86 93.88,14.97 104.06,14.97 104.82,15.73 116.1,15.73 119.6,19.23 119.6,19.26 121.68,21.34 125.4,21.34 127.49,23.43 127.49,26.5 128.53,27.54 140.71,27.54 141.84,28.68 141.84,29.65 142.28,30.08 143.63,30.08 144.01,30.46 147.1,30.46 147.76,31.12 149.06,31.12 149.54,31.61 157.27,31.61 158.05,30.82 159.28,30.82 159.99,31.53 159.99,35.58 162.15,37.74 162.15,46.48 172.29,56.63 172.29,61.02 171.29,62.03 171.29,68.26 174.35,71.32 174.35,75 173.4,75.95 173.4,77.23 173.26,77.37 154,77.37 153.02,78.34 152.11,78.34 v1(151.67,78.79)
HWPG_1.5V: length 192.6
  TOP w0.127: D21.1 18.86,24.54 19.81,23.59 22.94,23.59 v1(23.27,23.93) 23.53,24.18 23.53,25.04 25.03,26.54 28.76,26.54 v1(29.47,25.83)
  IN1 w0.089: v1(158.78,61.39) 159.4,60.77 159.4,57.76 159.79,57.36 159.79,51.35 158.99,50.55 158.62,50.55 157.56,49.49 154.43,49.49 154.04,49.11 154.04,38.57 153.62,38.14 152.81,38.14 152.5,38.14 151.61,37.25 151.61,36.56 149.85,34.8 149.85,33.12 146.36,29.63 145.14,29.63 140.52,25.01 140.52,24.13 139.72,23.33 138.21,23.33 136.88,22 135.32,22 134.47,22.85 126.14,22.85 125.11,21.82 118.77,21.82 116.37,19.42 114.21,19.42 111.77,16.98 99.25,16.98 98.65,16.39 90.84,16.39 86.4,11.94 76.62,11.94 74.89,10.22 60.66,10.22 58.28,12.59 49.09,12.59 47.56,14.13 47.11,14.13 47.11,14.13 37.88,14.13 34.26,17.74 34.26,19.37 33.2,20.42 33.2,21.87 29.47,25.6 v1(29.47,25.83)
  BOTTOM w0.127: v1(158.78,61.39) 159.54,61.39 159.93,61.01 PU12.1 159.93,59.38 159.76,59.22 PR218.2
HWPG_1.05V_EC#: length 7.3
  TOP w0.127: U14.122 26.71,40.81 26.45,41.07 26.45,42.62 v1(26.07,43) 25.9,43.17 25.9,43.47 25.51,43.86 25.23,43.86 24.92,44.17 24.92,45.71 R225.1
HWPG_1.8V_S5: length 274.7
  TOP w0.127: v1(20.29,51.36) 19.91,50.98 v1(19.72,50.98) 19.11,50.37 19.11,46.8 19.72,46.2 19.72,44.6 D9.1
  IN1 w0.089: v1(20.29,51.36) 21.1,50.54 21.1,46.56 23.92,43.74 25.13,43.74 28.76,40.1 29.65,40.1 30.21,39.54 30.21,38.46 31.04,37.64 31.04,35.46 31.99,34.52 32.83,34.52 33.26,34.09 33.26,33.22 35.01,31.47 35.01,28.72 35.55,28.18 41.58,28.18 43.28,26.48 43.28,22.94 44.66,21.56 44.66,20.27 48.12,16.81 49.56,16.81 v1(49.69,16.69)
  IN3 w0.127: v1(49.69,16.69) 50.32,16.69 51.22,15.79 54.75,15.79 57.35,13.19 73.02,13.19 74.93,15.1 85.38,15.1 86.9,16.62 110.96,16.62 112.36,18.02 117.31,18.02 118.84,19.55 118.84,19.67 121.27,22.1 125.08,22.1 126.73,23.75 126.73,26.82 128.21,28.31 140.38,28.31 141.08,29.01 141.08,30.39 141.65,30.95 143.42,30.95 143.69,31.22 146.78,31.22 147.44,31.88 148.74,31.88 149.86,33.01 151.35,33.01 151.85,32.5 157.45,32.5 158.37,31.58 158.97,31.58 159.23,31.84 159.23,35.89 161.39,38.05 161.39,46.8 163.66,49.07 166.47,51.88 166.47,58.13 165.03,59.56 163.48,59.56 162.86,60.18 162.86,66.83 163.98,67.96 164.8,67.96 166.62,69.78 166.62,72.37 164.62,74.37 153.85,74.37 153.2,73.72 143.65,73.72 142.96,74.41 142.07,74.41 141.81,74.67 138.59,74.67 138.26,74.34 v1(138.26,74.34)
  BOTTOM w0.127: v1(138.26,74.34) 137.58,74.34 PR148.1 ; v1(20.29,51.36) 18.83,51.36 17.79,52.4 17.79,57.5 18.25,57.97 18.83,57.97 19.08,57.72 PR220.2 19.59,58.09 19.85,58.35 PR215.2
HWPG_1.24V_S5: length 169.8
  TOP w0.127: v1(59.44,45.95) 52.99,52.4 52.73,52.4 51.47,53.66 51.47,54.61 50.55,55.52 44.04,55.52 43.41,56.16 42.58,56.16 39.24,52.81 39.24,52.33 37.93,51.01 37.17,51.01 36.94,50.79 35.02,48.87 34.17,48.87 32.97,47.67 27.84,47.67 25.2,50.3 21.84,50.3 v1(20.35,48.82) 19.62,48.08 19.62,47.01 20.23,46.41 20.23,44.39 19.94,44.11 19.94,40.9 19.79,40.76 19.79,39.04 19.28,38.53 D14.1
  IN2 w0.127: v1(59.44,45.95) 59.44,42.09 63.41,38.12 97.72,38.12 103.72,44.12 112.17,44.12 115.58,47.52 115.58,56.92 119.01,60.35 124.31,60.35 125.55,61.59 125.55,64.36 129.19,67.99 133.38,67.99 134.04,68.65 v1(134.04,75.56)
  BOTTOM w0.127: PR147.2 134.02,74.35 PR143.2 134.06,75.56 v1(134.04,75.56)
HWPG_2.5V: length 108.2
  TOP w0.127: v1(109.63,7.54) 109.24,7.93 PR114.2 PR109.1 ; D22.1 19.6,23.04 19.69,23.14 v1(21.37,23.14) 21.57,23.34 23.4,23.34 23.78,23.72 23.78,24.93 24.62,25.77 v1(24.89,25.77)
  IN1 w0.089: v1(109.63,7.54) 109.23,7.94 83.92,7.94 82.9,6.92 65.64,6.92 65.05,7.51 59.54,7.51 58.24,8.81 40.67,8.81 40.27,9.21 32.18,9.21 29.98,11.41 29.98,13.86 24.89,18.95 v1(24.89,25.77)
I2C_4_SCL_R: length 125.1
  TOP w0.14: R100.2 86.52,69.65 86.9,69.65 87.14,69.42 87.51,69.42 87.99,68.93 v1(87.99,68.91) ; v1(73.31,18.72) 71.94,17.35 71.94,14.56 v1(72.15,14.35) 72.15,13.03 74.14,11.03 74.72,11.03 75.69,12 78.38,12 78.65,11.73 78.65,10.34 78.91,10.07 Q20.1
  IN1 w0.089: v1(87.99,68.91) 87.62,69.28 87.13,69.28 86.8,69.61 84.36,69.61 82.72,67.97 81.32,67.97 80.29,66.95 80.28,66.92 79.84,66.49 79.2,66.49 78.55,65.84 78.55,65.41 76.29,63.15 73.16,63.15 72.42,62.41 70.86,62.41 70.35,61.9 66.87,61.9 65.6,60.63 64.23,60.63 62.99,59.39 62.99,57.47 59.49,53.97 59.49,50.32 54.27,45.1 52.54,45.1 49.4,41.96 49.4,37.96 46.67,35.23 46.67,32.85 46.05,32.23 46.05,26.38 45.03,25.36 45.03,23.67 47.3,21.39 47.3,20.8 48.73,19.37 60.66,19.37 62.1,17.94 72.53,17.94 v1(73.31,18.72)
  BOTTOM w0.089: v1(87.99,68.91) 87.99,68.84 U22.R49
I2C_4_SDA_R: length 125.1
  TOP w0.14: Q20.4 76.87,11.37 76.63,11.61 75.85,11.61 74.88,10.63 73.77,10.63 72.6,11.81 v1(72.42,11.81) 71.48,12.75 71.48,17.64 v1(72.55,18.72) ; v1(87.3,68.88) 87.3,68.91 87.19,69.02 R104.2
  IN1 w0.089: v1(87.3,68.88) 86.96,68.88 86.58,69.26 86.27,69.26 85.8,68.8 84.04,68.8 82.86,67.63 81.46,67.63 80.56,66.72 80.54,66.7 79.98,66.15 79.34,66.15 78.89,65.7 78.89,65.26 76.43,62.81 73.97,62.81 73.06,61.9 71.41,61.9 70.5,60.99 66.45,60.99 64.99,59.54 64.99,58.66 63.57,57.24 63.25,57.24 59.84,53.82 59.84,50.18 54.41,44.75 52.68,44.75 49.74,41.81 49.74,41.39 49.8,41.33 50.58,41.33 50.65,41.25 50.65,41.05 50.58,40.97 49.8,40.97 49.74,40.91 49.74,40.68 49.8,40.62 50.6,40.62 50.68,40.54 50.68,40.34 50.6,40.26 49.8,40.26 49.74,40.2 49.74,39.97 49.8,39.91 50.6,39.91 50.68,39.83 50.68,39.63 50.6,39.55 49.8,39.55 49.74,39.49 49.74,39.26 49.8,39.19 50.6,39.19 50.68,39.12 50.68,38.91 50.6,38.84 49.8,38.84 49.74,38.77 49.74,38.55 49.8,38.48 50.65,38.48 50.73,38.41 50.73,38.2 50.65,38.13 49.8,38.13 49.74,38.06 49.74,37.79 47.01,35.06 47.01,32.71 46.39,32.09 46.39,25.84 47.65,24.58 47.65,20.94 48.87,19.72 61.01,19.72 62.45,18.28 72.36,18.28 72.55,18.46 v1(72.55,18.72)
  BOTTOM w0.089: v1(87.3,68.88) 87.68,68.5 U22.R51
I2C_SEL_PIN: length 3
  TOP w0.127: U6.31 116.26,83.92 116.11,84.07 115.53,84.07 115.09,84.5 115.09,85.01 114.69,85.42 R39.2
I2C_TP_SCL_R: length 6.7
  TOP w0.14: R369.1 78.26,9.83 78.02,10.07 Q20.6 76.75,10.07 v1(76.49,10.34)
  BOTTOM w0.14: v1(76.49,10.34) 76.75,10.07 77.87,10.07 78.15,10.35 CN12.6
I2C_TP_SDA_R: length 6.3
  TOP w0.14: v1(81.54,10.54) 81.54,11.24 R359.1 81.42,11.37 Q20.3
  BOTTOM w0.14: CN12.5 79.15,11.61 79.48,11.28 80.8,11.28 v1(81.54,10.54)
ICMNT: length 167.9
  TOP w0.127: C261.2 43.43,24.85 v1(42.96,25.32) 42.45,25.32 41.36,26.42 39.58,26.42 39.21,26.78 U14.67 37.62,26.78 36.94,27.47 35.55,27.47 34.82,28.2 34.82,29.66 33.59,30.88 32.27,30.88 31.77,31.38 28.42,31.38 28.05,31.01 25.25,31.01 v1(24.8,30.55) ; PC111.2 147.34,5.26 v1(146.72,5.89) PR124.2
  IN1 w0.089: v1(146.72,5.89) 146.13,6.48 136.77,6.48 132.66,10.59 124.55,10.59 123.9,9.94 121.13,9.94 118.97,7.78 110.56,7.78 110.01,8.32 83.76,8.32 82.74,7.3 65.8,7.3 65.21,7.89 59.7,7.89 58.39,9.19 40.83,9.19 40.43,9.59 32.34,9.59 31.83,10.1 31.83,12.55 26.12,18.26 26.12,26.48 25.96,26.65 25.96,29.39 v1(24.8,30.55)
IERR: length 6.2
  BOTTOM w0.089: 85.22,66.62 85.69,66.62 85.73,66.65 86.03,66.65 86.13,66.56 86.38,66.56 86.47,66.65 86.74,66.65 U22.W53
  BOTTOM w0.114: 85.22,66.62 84.65,66.62
  BOTTOM w0.14: 84.65,66.62 82.98,66.62 v1(82.96,66.6) 82.94,66.62 81.59,66.62 R486.1
IMVP_PWRGD: length 71.2
  TOP w0.127: D10.1 17.99,42.09 17.71,42.37 17.71,53.39 17.95,53.63 18.94,53.63 19.34,54.02 v1(19.84,54.02) 19.97,53.9 23.06,53.9 28.26,48.7 32.54,48.7 33.74,49.9 34.59,49.9 36.74,52.04 37.5,52.04 38.21,52.75 38.21,53.84 39.07,54.7 39.67,54.7 42.15,57.19 44.59,57.19 45.19,56.58 51.98,56.58 v1(52.07,56.67)
  IN3 w0.127: v1(52.07,56.67) 53.16,57.76 53.16,59.34 53.02,59.49 53.02,62.41 52.03,63.4 52.03,67.13 50.96,68.2 50.96,68.46 49.51,69.9 v1(49.51,70.66)
  BOTTOM w0.127: PR151.2 49.51,71.46 v1(49.51,70.66) 49.51,70.11 PR156.2
IMVP_PWRGD_VNN: length 39.9
  TOP w0.127: PR25.2 38.82,67.56 v1(39.15,67.23) ; D8.1 18.73,46.15 18.73,51.26 v1(19.84,52.37) v1(20.35,52.88)
  IN1 w0.089: v1(20.35,52.88) 20.35,53.18 22,54.82 22,59.58 22.85,60.44 28.67,60.44 29.12,60.88 37.76,60.88 38.51,61.64 38.51,66.6 v1(39.15,67.23)
  BOTTOM w0.127: v1(39.15,67.23) 38.89,67.49 PR175.2
INT_AMIC-VREFO: length 4.1
  TOP w0.203: U16.27 180.88,21.72 181.25,22.09 R320.2
  TOP w0.508: R320.2 C263.1 181.06,24.12 v1(181.06,24.94)
INT_EDP_HPD#: length 117.4
  TOP w0.127: R56.1 162.26,80.32 161.96,80.02 161.96,79.42 161.58,79.04 v1(161.58,78.03) 161.39,77.84 161.39,77.2 161.38,77.2 161.38,76.45 161.07,76.13 Q4.3 161.9,75.74 v1(162.11,75.94)
  IN1 w0.089: v1(117,96.37) 117.16,96.21 117.16,94.24 116.75,93.84 115.97,93.84 115.28,93.15 115.28,92.33 114.95,92 114.95,87.11 114.56,86.73 114,86.73 112.91,87.81 109.23,87.81 107.06,85.65 99.1,85.65 v1(96.28,88.47)
  IN3 w0.127: v1(162.11,75.94) 161.7,76.35 150.83,76.35 149.57,77.61 149.57,79.36 148.62,80.31 143.48,80.31 143.29,80.5 143.29,82.47 142.64,83.12 122.93,83.12 122.33,83.72 122.33,91.36 120.93,92.77 120.93,93.78 118.34,96.37 v1(117,96.37)
  BOTTOM w0.089: U22.B39 92.82,74.94 92.87,74.99 92.87,75.96
  BOTTOM w0.14: 92.87,75.96 92.87,76.84 91.51,78.2 91.51,78.71 90.94,79.29 90.94,79.71 91.51,80.28 91.51,82.05 91.72,82.26 91.72,83.74 92.16,84.18 92.78,84.8 95,84.8 96.28,86.07 v1(96.28,88.47)
INT_HDMI_HPD#: length 45.4
  IN1 w0.089: v1(114.33,87.55) 113.57,88.31 108.49,88.31 107.48,87.3 106.08,87.3 104.8,86.03 99.25,86.03 97.04,88.24 97.04,88.58 96.48,89.14 v1(95.54,89.14)
  BOTTOM w0.089: U22.C39 92.82,74.26 92.63,74.45 92.53,74.59 92.53,74.72 92.63,74.86 92.64,74.87 92.64,75.75
  BOTTOM w0.127: R409.1 114.09,85.27 114.84,85.27 115.25,85.67 Q30.3 115.25,86.64 v1(114.33,87.55)
  BOTTOM w0.14: v1(95.54,89.14) 95.54,89.14 95.83,88.85 95.83,86 94.89,85.07 92.67,85.07 91.46,83.85 91.46,82.32 91.24,82.1 91.24,80.34 90.62,79.72 90.62,77.73 90.96,77.39 91.35,77.39 92.64,76.09 92.64,75.75
INT_HDMICLK+: length 25.6
  TOP w0.14: C71.2 121.42,75.73 121.56,75.59 121.56,75.4 121.34,75.17 120.72,75.17 119.28,73.73 119.28,72.93 119.2,72.85 v1(118.96,72.85)
  BOTTOM w0.089: 111.37,63.84 111.3,63.78 111.01,63.78 110.49,63.26 109.64,63.26 109.37,63.52 109.2,63.52 109.05,63.38 109.05,63.3 109.14,63.2 U22.AG2
  BOTTOM w0.14: 111.37,63.84 111.99,63.84 112.32,64.17 112.92,64.17 113.25,63.84 115.11,63.84 115.96,64.7 118.69,64.7 120.67,66.68 120.67,70.55 119.27,71.95 119.27,72.72 119.15,72.85 v1(118.96,72.85)
INT_HDMICLK-: length 25.6
  TOP w0.14: C72.2 122.02,75.73 121.83,75.54 121.83,75.29 121.45,74.9 120.83,74.9 119.55,73.62 119.55,73.02 v1(119.72,72.85)
  BOTTOM w0.089: 111.37,63.57 111.34,63.6 111.08,63.6 110.56,63.08 109.52,63.08 109.38,62.94 109.15,62.94 108.89,63.2 U22.AG3
  BOTTOM w0.14: 111.37,63.57 112.1,63.57 112.43,63.9 112.81,63.9 113.14,63.57 115.22,63.57 116.07,64.43 118.8,64.43 120.94,66.57 120.94,70.66 119.54,72.06 119.54,72.66 v1(119.72,72.85)
INT_HDMITX0N: length 29.8
  TOP w0.14: C57.2 120.88,78.35 120.88,78.18 120.66,77.96 120.66,77.41 v1(120.94,77.14)
  BOTTOM w0.089: U22.AJ3 108.91,62.3 109.18,62.03 109.2,62.03 109.2,62.03 109.38,62.03 109.39,62.03 109.49,62.13 110.41,62.13 110.97,61.57 111.26,61.57 111.31,61.53 111.37,61.53
  BOTTOM w0.14: v1(120.94,77.14) 120.76,76.96 120.76,74.06 122,72.82 122,71.95 122.51,71.44 122.51,65.91 122.3,65.71 122.3,65.7 119.45,62.86 116.73,62.86 115.4,61.53 111.37,61.53
INT_HDMITX0P: length 29.7
  TOP w0.14: v1(120.17,77.14) 120.32,77.14 120.4,77.21 120.4,78.07 120.62,78.29 120.62,78.78 120.53,78.87 120.39,78.87 C56.2
  BOTTOM w0.089: 111.33,61.79 111.31,61.79 111.26,61.75 111.04,61.75 110.49,62.3 109.29,62.3 U22.AJ2
  BOTTOM w0.14: 111.33,61.79 115.29,61.79 116.62,63.12 119.34,63.12 122.1,65.88 122.24,66.02 122.24,71.33 121.74,71.84 121.74,72.71 120.49,73.95 120.49,77.05 120.4,77.14 v1(120.17,77.14)
INT_HDMITX1N: length 24.4
  TOP w0.14: v1(118.16,72.83) 117.99,73 117.99,73.97 118.56,74.53 118.99,74.53 119.5,75.04 119.5,75.44 C70.2
  BOTTOM w0.089: 111.18,64.69 111.14,64.74 110.82,64.74 110.2,64.11 109.69,64.11 109.43,63.85 109.15,63.85 108.9,64.1 U22.AE3
  BOTTOM w0.14: 111.18,64.69 111.19,64.69 113.14,64.69 113.45,64.38 114.91,64.38 115.75,65.22 118.47,65.22 120.15,66.89 120.15,70.34 119.38,71.1 118.77,71.1 117.99,71.88 117.99,72.65 v1(118.16,72.83)
INT_HDMITX1P: length 24.4
  TOP w0.14: C69.2 119.09,75.73 119.23,75.59 119.23,75.15 118.88,74.8 118.45,74.8 117.72,74.08 117.72,72.91 117.64,72.83 v1(117.4,72.83)
  BOTTOM w0.089: 111.21,64.96 111.19,64.96 111.14,64.91 110.75,64.91 110.12,64.28 109.48,64.28 109.35,64.41 109.22,64.41 109.07,64.27 109.07,64.17 109.14,64.1 U22.AE2
  BOTTOM w0.14: 111.21,64.96 113.25,64.96 113.56,64.65 114.8,64.65 115.64,65.49 118.36,65.49 119.88,67 119.88,70.22 119.27,70.84 118.65,70.84 117.72,71.77 117.72,72.68 117.58,72.83 v1(117.4,72.83)
INT_HDMITX2N: length 28.9
  TOP w0.14: v1(117.89,77.14) 117.69,77.33 117.69,77.96 117.83,78.1 117.83,78.35 C55.2
  BOTTOM w0.089: U22.AH3 109.04,62.69 109.25,62.69 109.46,62.48 109.81,62.48 109.99,62.66 110.83,62.66 111.05,62.44 111.35,62.44 111.4,62.39 111.42,62.39
  BOTTOM w0.14: 111.42,62.39 115.15,62.39 116.4,63.64 119.13,63.64 121.28,65.79 121.72,66.24 121.72,71.11 121.16,71.67 121.16,72.54 117.72,75.98 117.72,76.97 v1(117.89,77.14)
INT_HDMITX2P: length 28.9
  TOP w0.14: C54.2 117.29,78.81 117.48,78.81 117.57,78.73 117.57,78.21 117.42,78.07 117.42,77.21 117.35,77.14 v1(117.13,77.14)
  BOTTOM w0.089: 111.42,62.66 111.4,62.66 111.35,62.61 111.13,62.61 110.9,62.84 109.68,62.84 U22.AH1
  BOTTOM w0.14: 111.42,62.66 115.04,62.66 116.29,63.91 119.02,63.91 121.05,65.94 121.46,66.35 121.46,71 120.9,71.56 120.9,72.43 117.46,75.87 117.46,77.01 117.33,77.14 v1(117.13,77.14)
INTRUDER#: length 10.7
  TOP w0.127: v1(99.65,72.26) 99.22,72.69 99.22,73.95 98.29,74.88 98.29,75.81 97.84,76.26 97.84,76.56 v1(97.59,76.81) 97.19,77.21 97.19,79.42 97.44,79.68 97.44,79.8 R52.1
  BOTTOM w0.089: U22.H25 99.22,71.83 v1(99.65,72.26)
IOAC_LAN_WAKE#: length 73.2
  TOP w0.127: v1(25.28,85.27) 25.79,85.77 R36.2 ; U14.87 37.5,34.78 37.3,34.97 36.46,34.97 34.65,33.17 31.6,33.17 v1(31.29,32.87)
  IN1 w0.089: v1(18.45,54.15) 17.49,53.2 17.49,48.98 18.66,47.81 18.66,47.65 23.53,42.78 24.73,42.78 25.69,41.83 25.69,40.78 27.51,38.96 27.51,36.95 31.15,33.31 31.15,33 v1(31.29,32.87)
  IN3 w0.127: v1(18.45,54.15) 18.89,54.6 18.89,55.61 21.61,58.33 21.61,62.01 22.09,62.49 22.86,62.49 23.25,62.88 23.25,65.69 22,66.93 22,70.05 21.43,70.62 21.43,80.18 23.07,81.82 23.07,83.62 24.72,85.27 v1(25.28,85.27)
IOAC_RST#: length 124.8
  TOP w0.14: v1(60.86,60.65) 61.24,60.28 R636.1 ; R287.1 v1(39.78,33.96) 39.76,33.98 U14.85 37.09,33.98 v1(36.74,34.34) ; v1(25.28,87.81) 25.28,87.88 25.93,88.53 R23.1
  IN1 w0.089: v1(36.74,34.34) 40.29,34.34 42.64,36.68 42.64,42.79 42.38,43.04 42.38,45.95 43.09,46.66 43.09,48.31 44.61,49.83 44.61,54.28 46.51,56.18 46.51,57.08 48.89,59.46 51.44,59.46 53.63,61.64 55.34,61.64 56.69,62.99 56.69,63.72 v1(57.16,64.18)
  IN3 w0.127: v1(60.86,60.65) 60.86,61.01 57.69,64.18 v1(57.16,64.18) ; v1(25.28,87.81) 21.67,84.2 21.67,82.4 20.03,80.76 20.03,71.45 19.59,71.01 19.59,66.55 18.74,65.7 18.74,58.27 17.84,57.36 17.84,53.74 v1(18.45,53.14)
  BOTTOM w0.14: v1(18.45,53.14) 19.2,52.39 24.67,52.39 25.42,51.64 25.42,51.11 26.63,49.9 27.28,49.26 28.49,48.05 29.08,48.05 31.41,45.72 31.41,43.47 31.86,43.02 32.19,43.02 33.1,42.11 33.89,42.11 33.89,42.11 34.43,42.11 34.43,42.11 35.34,42.11 35.35,42.11 35.67,42.11 37.33,40.45 37.33,37.27 36.74,36.68 v1(36.74,34.34)
IOAC_WIGIG_RST#: length 2.3
  TOP w0.14: R278.1 v1(21.37,38.52) 21.92,37.98 U14.2
IOAC_WLAN_WAKE#: length 35.3
  TOP w0.14: v1(30.45,32.91) 29.98,32.44 26.26,32.44 25.3,33.4 24.67,33.4 23.65,32.38 U14.16
  IN1 w0.089: v1(30.45,32.91) 30.88,32.47 30.88,30.53 31.4,30.01 31.4,28.13 31.86,27.67 33.6,27.67 34.42,26.85 41.29,26.85 42.13,26 42.13,20.58 v1(43.87,18.85)
  BOTTOM w0.127: R592.1 43.72,17.58 43.72,18.69 v1(43.87,18.85)
IRQ_SERIRQ: length 16.9
  TOP w0.127: R207.1 22.27,47.56 v1(22.26,47.55) 22.27,47.54 22.27,47.01 22.74,46.53 22.74,44.08 U10.3 22.4,42.97 R270.1 23.41,41.71 23.15,41.45 21.75,41.45 20.05,39.75 20.05,37.57 20.42,37.2 21.18,37.2 21.59,36.78 U14.5
ISEN1N_VCGI: length 24.2
  BOTTOM w0.178: PR135.2 PR136.2 66.44,76.63 66.25,76.44 66.25,72.39 65.23,71.37 65.23,67.54 64.62,66.92 64.06,66.92 62.74,65.6 60.08,65.6 59.8,65.32 PC177.1 59.47,64.32 PC182.1 58.69,63.54 PR194.2 57.86,64.01 57.86,64.47 56.96,65.36 PU10.21
ISEN1N_VNN: length 48.3
  TOP w0.178: PR11.2 v1(42.96,77.27)
  TOP w0.203: PC47.1 29.5,62.03 v1(29.5,62.53) 29.59,62.63 31.12,62.63 31.66,63.17 31.66,64.32 PU1.21
  TOP w0.254: PC47.1 28.5,61.78 PR51.2 PC49.1
  IN1 w0.178: v1(29.5,62.53) 29.49,62.53 28.25,63.77 28.25,67.62 26.99,68.88 24.79,68.88 23.57,70.11 23.57,77.49 24.16,78.09 42.68,78.09 42.96,77.81 v1(42.96,77.27)
  BOTTOM w0.178: v1(42.96,77.27) 42.95,77.27 PR134.2
ISEN1P_VCGI: length 4.8
  BOTTOM w0.178: PR182.2 v1(60.28,66.09) 59.48,66.09 PC177.2 PR183.1 57.44,66.1 57.11,65.76 PU10.20
ISEN1P_VNN: length 10.3
  TOP w0.203: PC49.2 26.45,61.13 v1(26.45,61.26) 26.45,61.65 PR47.1 27.33,62.9 PR41.2 28.35,63.68 29.01,63.02 31.04,63.02 31.32,63.3 31.32,63.75 30.95,64.12 30.95,64.58 31.12,64.75 PU1.20
ISOLATEB: length 8.1
  TOP w0.127: R26.2 R25.1 27.34,87.18 v1(27.34,86.78) ; U3.20 27.48,90.04 v1(27.32,90.19)
  IN1 w0.089: v1(27.32,90.19) 27.51,90.19 28.26,89.45 28.26,87.23 27.81,86.78 v1(27.34,86.78)
KB_BL_LED: length 123.1
  TOP w0.127: Q27.2 117.15,8.28 v1(116.87,8.56)
  IN1 w0.089: v1(25.38,38.28) 25.34,38.24 25.34,37.14 25.77,36.71 25.77,30.71 26.72,29.76 26.72,26.96 26.89,26.8 26.89,18.58 33.43,12.03 33.43,10.62 33.69,10.36 40.75,10.36 41.14,9.96 58.71,9.96 60.01,8.65 65.52,8.65 66.12,8.06 82.42,8.06 83.51,9.15 114.38,9.15 114.97,8.56 v1(116.87,8.56)
  BOTTOM w0.127: v1(25.38,38.28) 23.7,38.28 23.5,38.48 23.5,39.39 v1(24.29,40.18) 25.31,41.2 R548.2
KB_BL_LED_R: length 6.6
  TOP w0.127: v1(30.18,41.96) 30.31,41.83 U14.113
  BOTTOM w0.127: v1(30.18,41.96) 30.18,41.95 29.62,41.95 29.25,41.58 v1(28.61,41.58) 28.4,41.78 26.45,41.78 26.2,41.54 R548.1
L_SPK+:
  vias: v1(162.85,11.58) v1(162.85,10.84) v1(174.2,17.98) v1(174.83,17.98)
L_SPK+_CN:
  vias: v1(163.23,6.53) v1(163.86,6.53)
L_SPK-:
  vias: v1(164.75,10.84) v1(165.39,10.84) v1(174.2,17.35) v1(174.83,17.35)
L_SPK-_CN:
  vias: v1(165.13,6.53) v1(165.77,6.53)
LAD0_C: length 35.9
  IN3 w0.127: v1(41.26,41.68) 40.83,42.11 40.83,42.95 39.21,44.57 39.21,45.62 37.28,47.55 37.28,49.14 36.79,49.63 36.79,55.5 v1(35.21,57.07)
  BOTTOM w0.14: v1(35.21,57.07) 36.36,58.22 R517.2 ; v1(41.26,41.68) 40.59,41.01 40.59,39.87 38.73,38 38.73,32.71 37.62,31.6 37.62,28.67 37.15,28.2 CN10.64
LAD1_C: length 31.2
  IN3 w0.127: v1(41.28,41.03) 40.63,41.68 40.29,41.68 39.9,42.06 39.9,43.33 36.95,46.29 36.95,49 36.46,49.49 36.46,52.14 v1(35.47,53.14)
  BOTTOM w0.14: CN10.66 37.65,28.22 37.96,28.53 37.96,31.46 39.07,32.57 39.07,37.86 40.94,39.73 40.94,40.68 v1(41.28,41.03) ; R530.2 35.84,53.14 v1(35.47,53.14)
LAD2_C: length 26.6
  IN3 w0.127: v1(39.25,48.22) 39.87,47.6 39.87,44.85 41.72,43 41.72,41.65 v1(42.19,41.18)
  BOTTOM w0.14: R537.2 37.25,49.07 38.64,49.07 39.25,48.46 v1(39.25,48.22) ; v1(42.19,41.18) 41.28,40.27 41.28,39.58 39.41,37.72 39.41,32.42 38.31,31.32 38.31,28.37 38.15,28.21 CN10.68
LAD3_C: length 22.3
  IN3 w0.127: v1(42.16,41.84) 42.42,42.11 42.42,42.92 v1(40.59,44.75)
  BOTTOM w0.14: v1(42.16,41.84) 42.64,41.37 42.64,40.99 41.62,39.97 41.62,39.44 40.42,38.24 40.42,36.91 39.76,36.24 39.76,32.28 38.65,31.17 CN10.70 ; v1(40.59,44.75) 39.53,45.82 R540.2
LAN_MCT0: length 3.6
  TOP w0.508: v1(46.86,86.62) 46.39,86.16 R29.1
  BOTTOM w0.508: U20.24 v1(46.86,86.62)
LAN_MCT1: length 4.2
  TOP w0.508: R24.1 46.59,88.7 46.9,89 v1(46.9,89.62)
  BOTTOM w0.508: U20.21 v1(46.9,89.62)
LAN_MCT2: length 4.4
  TOP w0.508: R21.1 46.52,91.24 46.77,91.49 v1(46.77,92.62)
  BOTTOM w0.508: U20.18 v1(46.77,92.62)
LAN_MCT3: length 4.8
  TOP w0.508: R11.1 46.31,93.78 46.9,94.36 v1(46.9,95.3)
  BOTTOM w0.508: U20.15 46.57,95.62 v1(46.9,95.3)
LAN_MX0+: length 21.8
  IN3 w0.127: v1(48.5,89.56) 48.63,89.69 48.96,89.69 52.38,93.11 61.23,93.11 61.77,93.66 61.77,94.69 61.57,94.89 CN4.1
  BOTTOM w0.14: v1(48.5,89.56) 48.35,89.7 48.17,89.7 48.04,89.57 48.04,88.9 47.11,87.97 46.3,87.97 45.95,87.62 U20.23
LAN_MX0-: length 21.8
  IN3 w0.127: CN4.2 60.86,94.74 61.28,94.74 61.46,94.56 61.46,93.78 61.1,93.42 52.25,93.42 48.83,90 48.58,90 48.5,90.08 v1(48.5,90.32)
  BOTTOM w0.14: U20.22 45.95,88.62 46.3,88.28 46.98,88.28 47.73,89.02 47.73,89.7 48.04,90.01 48.4,90.01 48.5,90.1 v1(48.5,90.32)
LAN_MX1+: length 17.5
  IN2 w0.127: CN4.3 59.53,94.26 58.11,92.84 52.18,92.84 52.05,92.84 50.54,91.32 48.61,91.32 v1(48.47,91.18)
  BOTTOM w0.14: U20.20 45.91,90.62 46.26,90.97 47.27,90.97 47.62,91.32 48.33,91.32 v1(48.47,91.18)
LAN_MX1-: length 17.4
  IN2 w0.127: v1(48.47,91.94) 48.47,91.69 48.54,91.62 50.41,91.62 51.92,93.14 52.3,93.14 57.98,93.14 58.16,93.32 58.16,93.58 57.52,94.22 57.52,94.53 57.36,94.7 56.74,94.7 CN4.6
  BOTTOM w0.14: v1(48.47,91.94) 48.47,91.7 48.39,91.63 47.49,91.63 47.14,91.28 46.26,91.28 45.91,91.62 U20.19
LAN_MX2+: length 14.8
  IN1 w0.089: v1(47.85,93.27) 48.14,93.56 51.63,93.56 52.01,93.18 56.82,93.18 58.07,94.43 CN4.4
  BOTTOM w0.14: v1(47.85,93.27) 47.52,93.61 47.26,93.61 46.88,93.99 46.22,93.99 45.86,93.62 U20.17
LAN_MX2-: length 14.8
  IN1 w0.089: v1(47.85,94.04) 48.11,93.78 51.72,93.78 52.1,93.39 56.73,93.39 57.49,94.16 CN4.5
  BOTTOM w0.14: U20.16 45.92,94.62 46.25,94.3 47.01,94.3 47.39,93.91 47.73,93.91 v1(47.85,94.04)
LAN_MX3+: length 15.6
  BOTTOM w0.14: CN4.7 55.45,94.81 55.62,94.64 55.62,93.45 54.27,92.1 53.09,92.1 v1(52.61,91.62) 52.15,92.07 51.35,92.07 46.8,96.62 U20.14
LAN_MX3-: length 15.6
  BOTTOM w0.14: CN4.8 54.77,94.77 55.06,94.77 55.32,94.51 55.32,93.58 54.14,92.4 53.09,92.4 v1(52.61,92.89) 52.1,92.38 51.47,92.38 46.77,97.09 46.77,97.35 46.49,97.62 U20.13
LANCT3:
  vias: v1(40.04,92.51)
LANPWR#: length 60.6
  TOP w0.127: v1(21.22,70.2) 21.22,71.22 21.65,71.65 21.65,73.31 R93.2
  TOP w0.14: v1(33.25,31.37) 34.37,31.37 35.34,30.4 35.34,28.42 35.78,27.98 U14.70
  IN1 w0.089: v1(18.45,56.27) 19.08,55.64 19.08,47.77 23.68,43.17 24.89,43.17 26.07,41.99 26.07,40.94 27.83,39.18 28.26,39.18 28.63,38.82 28.63,36.64 31.8,33.47 31.8,33.46 33.25,32.01 v1(33.25,31.37)
  IN3 w0.127: v1(21.22,70.2) 21.75,69.67 21.75,66.82 22.99,65.58 22.99,62.99 22.75,62.75 21.99,62.75 21.36,62.12 21.36,58.46 19.17,56.27 v1(18.45,56.27)
LANVCC: length 5
  TOP w0.203: U3.11 31.24,93.14 30.89,93.49 30.89,94.4 C6.1
  TOP w0.508: C6.1 30.9,95.16 30.6,95.46 C4.2 30.6,96.66 v1(30.64,96.7)
  vias: v1(23.91,95.43) v1(25.18,99.62) v1(27.72,82.47) v1(27.72,81.84) v1(27.85,80.95) v1(28.35,82.47) v1(28.35,81.84) v1(32.67,87.81) v1(32.67,87.17)
LCDVCC:
  vias: v1(160.05,80.95) v1(160.69,80.95) v1(161.32,80.95) v1(161.45,80.31) v1(169.32,80.95)
LFRAME#_C: length 41.5
  IN3 w0.127: v1(43.04,39.92) 41.32,39.92 39.57,41.66 39.57,43.19 36.62,46.15 36.62,48.86 36.13,49.35 36.13,51.05 v1(35.34,51.84)
  BOTTOM w0.14: v1(35.34,51.84) 36.12,51.84 R532.1 ; CN10.73 39.4,21.26 40.16,22.02 41.79,22.02 42.75,22.98 42.75,27.75 43.28,28.29 43.28,29.06 42.52,29.82 42.52,31.1 41.47,32.15 41.47,37.81 42.66,39.01 42.66,39.54 v1(43.04,39.92)
LGATE_VCGI: length 10.7
  IN1 w0.635: v2(61.5,71.8) 55.4,71.8 54.31,70.71 v2(54.31,70.66)
  BOTTOM w0.203: 54.16,69.8 54.16,69.72 54.31,69.57 PU10.11
  BOTTOM w0.508: 54.16,69.8 54.16,70.51 v2(54.31,70.66)
  BOTTOM w0.635: v2(61.5,71.8) PQ16.4
LGATE_VNN: length 10.9
  TOP w0.203: PU1.11 33.78,68.46 33.23,69.01
  IN1 w0.635: v2(33.81,76.63) 35.24,75.2 35.24,71.83 v2(33.05,69.65)
  BOTTOM w0.635: PQ15.4 v2(33.81,76.63)
LGND:
  vias: v1(46.39,98.6)
LID#: length 292.7
  TOP w0.127: R384.2 D30.2 v1(173.77,8.52) 173.8,8.56 174.4,8.56 v1(174.78,8.18) ; D5.1 155.78,66.49 155.78,65.5 156.09,65.2 v1(156.09,64.18) 156.46,64.55 156.46,65.01 156.84,65.39 R125.2 ; v1(184.69,11.98) 184.94,12.23 184.94,13.51 185.45,14.02 HE1.1
  IN1 w0.089: v1(174.78,8.18) 173.71,7.1 173.71,6.09 171.94,4.32 160.86,4.32 158.91,6.27 155.48,6.27 ; 155.48,6.27 155.1,6.65 155.1,15.01 154.94,15.16 150.96,15.16 150.34,15.78 150.34,16.72 150.15,16.91 150.15,17.84 150.04,17.95 150.04,24.8 148.3,26.53 148.3,28.51 151.27,31.47 157.86,31.47 158.25,31.08 159.02,31.08 159.44,31.5 159.44,39.18 157.68,40.93 157.68,43.67 158.92,44.9 158.92,45.02 160.56,46.66 160.56,48.69 161.01,49.14 161.01,49.94 161.34,50.27 161.34,59.28 161.01,59.61 161.01,63.12 159.61,64.53 159.61,65.96 158.55,67.02 157.57,67.02 156.78,66.23 156.78,64.93 156.09,64.25 v1(156.09,64.18) ; 155.48,6.27 154.74,5.53 147.64,5.53 146.5,6.67 136.85,6.67 132.74,10.78 121.71,10.78 118.89,7.97 110.64,7.97 110.09,8.51 83.68,8.51 82.66,7.49 65.88,7.49 65.29,8.08 59.78,8.08 58.47,9.38 40.91,9.38 40.51,9.78 33.44,9.78 32.82,10.4 32.82,11.83 26.31,18.34 26.31,26.56 26.15,26.73 26.15,29.52 25.2,30.48 25.2,36.48 24.77,36.91 24.77,37.68 24.04,38.41 v1(24.04,38.78)
  BOTTOM w0.127: R549.2 25.05,39.8 v1(24.04,38.78) ; v1(174.78,8.18) 174.4,8.56 174.4,9.96 174.78,10.34 179.29,10.34 180.5,11.54 184.25,11.54 v1(184.69,11.98)
LID#_R: length 4
  TOP w0.127: v1(28.1,38.78) 28.31,39 U14.118
  BOTTOM w0.127: D40.1 28.09,38.78 v1(28.1,38.78) v1(27.34,39.55) 27.08,39.8 R549.1
LINE1-L: length 33.1
  TOP w0.203: U16.22 183.12,19.39 183.32,19.59 183.32,20.02 v1(183.55,20.24)
  TOP w0.508: v1(171.23,42.09) 171.83,42.09 C213.1
  BOTTOM w0.508: v1(183.55,20.24) 181.26,22.53 181.26,24.97 177.65,28.59 177.65,34.18 177.1,34.73 173.02,34.73 170.72,37.03 170.72,41.58 v1(171.23,42.09)
LINE1-R: length 43.8
  TOP w0.203: v1(183.55,19.1) 183.44,18.99 U16.21
  TOP w0.508: C185.1 171.92,52.09 v1(171.35,52.09)
  BOTTOM w0.508: v1(183.55,19.1) 183.93,19.1 184.44,19.61 184.44,20.61 183.17,21.88 183.17,24.32 178.54,28.95 178.54,34.55 177.47,35.62 173.39,35.62 171.61,37.4 171.61,40.69 172.24,41.32 172.24,51.2 v1(171.35,52.09)
LINE1-VREFO-L: length 33
  TOP w0.203: v1(179.5,23.59) 179.15,23.24 v1(179.15,23.06) 179.15,22.54 179.28,22.41 U16.31
  TOP w0.508: R226.2 v1(171.36,46.4)
  IN1 w0.508: v1(171.36,46.4) 170.47,45.52 170.47,37.01 172.5,34.97 177.22,34.97 178.49,33.7 178.49,24.61 v1(179.5,23.59)
LINE1-VREFO-R: length 37.6
  TOP w0.203: v1(179.69,22.76) 179.69,22.66 179.68,22.66 U16.30
  TOP w0.508: v1(171.47,50.02) 171.98,50.53 R203.2
  IN1 w0.508: v1(179.69,22.76) 179.75,22.76 180.73,23.74 180.73,24.94 179.38,26.29 179.38,34.07 177.59,35.86 172.87,35.86 171.36,37.37 171.36,40.56 171.99,41.2 171.99,45.78 172.24,46.04 172.24,46.77 171.99,47.03 171.99,48.71 172.06,48.78 172.06,49.29 171.99,49.36 171.99,49.5 v1(171.47,50.02)
LPC_CLKOUT0: length 4.8
  BOTTOM w0.089: U22.C37 93.72,74.26 93.53,74.45 93.43,74.59 93.43,74.72 93.53,74.86 93.6,74.93 93.6,75.14 93.25,75.48 93.25,76.38 93.5,76.63 R441.2
LPC_CLKOUT1: length 7.4
  BOTTOM w0.089: v1(91.42,79.55) 91.42,79.62 R421.2 R440.2 91.84,78.78 91.84,78.16 93.07,76.92 93.07,75.16 U22.A38
LPC_CLKRUN#_R: length 7.7
  BOTTOM w0.089: U22.C33 95.53,74.26 95.34,74.45 95.24,74.59 95.24,74.72 95.34,74.86 95.35,74.87 95.35,75.08 95.25,75.17 95.25,75.94 95.82,76.5 95.82,77.49 96.04,77.72 96.04,80.34 v1(96.09,80.39) 96.04,80.44 R424.2
LPC_LAD0: length 140.6
  TOP w0.14: v1(32.87,35.02) 32.22,34.37 26.09,34.37 25.63,34.84 23.58,34.84 23.53,34.78 U14.10
  IN1 w0.089: v1(32.87,35.02) 31.34,36.56 31.34,46.29 36.16,51.11 36.16,55.73 37.75,57.33 v1(37.86,57.33) 40.28,59.74 40.28,65.32 40.95,65.98 43.21,65.98 43.42,65.77 48.98,65.77 49.48,66.26 49.48,67.55 50.59,68.65 51.24,68.65 51.79,69.21 57.6,69.21 58.9,70.51 61.47,70.51 62.12,71.15 63.96,71.15 65.75,72.94 65.75,77.95 64.13,79.57 64.13,84.31 63.32,85.13 63.32,86.6 68.53,91.81 82.81,91.81 84.28,90.35 96.81,90.35 97.26,89.89 v1(97.26,89.84)
  BOTTOM w0.14: U28.24 38.92,53.11 38.77,53.26 38.77,55.17 38.13,55.8 38.13,56.19 R522.1 R517.1 37.86,57.61 v1(37.86,57.33) ; v1(97.26,89.84) 97.15,89.72 97.15,85.98 95.54,84.36 R412.1
LPC_LAD0_R: length 8.8
  BOTTOM w0.089: U22.A34 95.07,76.01 95.64,76.57 95.64,77.57 95.81,77.74 95.81,80.07 95.23,80.64 v1(95.23,81.33) 95.03,81.53 95.03,82.22 95.54,82.73 R412.2
LPC_LAD1: length 140.6
  TOP w0.14: U14.9 25.77,35.18 26.24,34.71 31.93,34.71 32.58,35.37 32.59,35.37 v1(32.87,35.66)
  IN1 w0.089: v1(95.36,79.91) 95.28,79.99 95.22,79.99 94.29,80.93 94.29,82.89 93.65,83.53 92.51,83.53 92.03,84.02 92.03,84.14 92.77,84.89 92.77,84.98 92.63,85.13 92.51,85.13 91.78,84.39 91.65,84.39 91.53,84.52 91.53,84.64 92.28,85.4 92.28,85.52 92.15,85.64 92.02,85.64 91.27,84.9 91.15,84.9 91.02,85.02 91.02,85.15 91.64,85.76 91.64,85.88 91.51,86.01 91.38,86.01 90.77,85.4 90.65,85.4 90.52,85.52 90.52,85.65 90.83,85.96 90.83,86.08 90.7,86.21 90.57,86.21 90.01,85.64 89.72,85.64 89.63,85.73 89.63,86.15 89.54,86.24 89.36,86.24 89.27,86.15 89.27,85.73 89.18,85.64 89,85.64 88.92,85.73 88.92,86.15 88.83,86.24 88.65,86.24 88.56,86.15 88.56,85.73 88.47,85.64 88.29,85.64 88.2,85.73 88.2,86.15 88.12,86.24 87.94,86.24 87.85,86.15 87.85,85.73 87.76,85.64 87.45,85.64 86.82,86.27 85.85,86.27 81.89,90.23 68.19,90.23 64.2,86.23 64.2,85.49 65.01,84.67 65.01,79.93 66.62,78.32 66.62,72.58 64.32,70.27 62.48,70.27 61.84,69.63 59.39,69.63 57.94,68.18 53.08,68.18 52.63,67.72 50.89,67.72 50.36,67.18 50.36,65.9 49.35,64.89 44.14,64.89 42.56,63.31 42.56,62.01 42.03,61.48 42.03,60.43 36.97,55.37 36.97,53.62 v1(37.71,52.88) 36.74,51.91 36.74,50.24 31.92,45.42 31.92,37.25 32.42,36.75 33.05,36.75 33.31,36.5 33.31,36.09 v1(32.87,35.66)
  BOTTOM w0.089: R442.1 95.41,79.86 v1(95.36,79.91)
  BOTTOM w0.14: v1(37.71,52.88) 37.38,52.88 R530.1 38.14,51.61 U28.21
LPC_LAD1_R: length 4.4
  BOTTOM w0.089: R442.2 95.38,78.4 94.8,77.82 94.8,74.88 94.91,74.72 94.91,74.59 U22.C34
LPC_LAD2: length 137.3
  TOP w0.14: v1(32.87,36.29) 32.87,36.29 31.63,35.06 26.38,35.06 25.85,35.58 U14.8
  IN1 w0.089: v1(32.87,36.29) 32.29,36.29 31.63,36.96 31.63,45.7 v1(34.12,48.19) 36.45,50.52 36.45,55.26 40.57,59.39 40.57,65.19 41.07,65.69 43.09,65.69 43.3,65.47 49.1,65.47 49.77,66.14 49.77,67.43 50.65,68.31 52.39,68.31 52.84,68.76 57.57,68.76 59.02,70.22 61.6,70.22 62.24,70.86 64.08,70.86 66.04,72.82 66.04,78.07 64.43,79.69 64.43,84.43 63.61,85.25 63.61,86.47 68.65,91.52 82.69,91.52 84.27,89.95 v1(96.55,89.95)
  BOTTOM w0.14: v1(96.55,89.95) 96.81,89.69 96.81,86.12 94.95,84.26 R411.1 ; U28.18 38.13,50.11 37.64,49.62 36.52,49.62 36.35,49.44 R537.1 35.89,49.2 34.88,48.19 v1(34.12,48.19)
LPC_LAD2_R: length 9.1
  BOTTOM w0.089: R411.2 v1(94.52,82.6) 94.8,82.32 94.8,80.41 94.95,80.26 94.95,78.3 94.62,77.98 U22.B35
LPC_LAD3: length 133
  TOP w0.14: U14.7 25.94,35.98 26.52,35.4 31.19,35.4 32.87,37.08 v1(32.87,37.18)
  IN1 w0.089: v1(32.87,37.18) 32.21,37.84 32.21,44.92 v1(35.84,48.54) 38.28,50.98 38.28,53.37 37.62,54.02 37.62,55.61 39.24,57.23 39.37,57.23 39.77,56.83 39.9,56.83 40.02,56.95 40.02,57.08 39.62,57.48 39.62,57.61 39.75,57.73 39.87,57.73 40.27,57.33 40.4,57.33 40.53,57.45 40.53,57.58 40.12,57.98 40.12,58.11 40.25,58.24 40.37,58.24 40.78,57.83 40.9,57.83 41.03,57.96 41.03,58.08 40.63,58.49 40.63,58.61 40.75,58.74 40.88,58.74 41.28,58.33 41.41,58.33 41.53,58.46 41.53,58.59 41.13,58.99 41.13,59.11 42.32,60.31 42.32,61.36 42.85,61.89 42.85,63.19 44.26,64.6 49.47,64.6 50.65,65.78 50.65,67.06 51.01,67.43 52.75,67.43 53.21,67.89 58.06,67.89 59.51,69.34 61.96,69.34 62.6,69.98 64.44,69.98 66.92,72.46 66.92,78.44 65.31,80.04 65.31,84.79 64.49,85.61 64.49,86.09 68.33,89.94 81.77,89.94 86.36,85.35 90.28,85.35 92.39,83.24 93.37,83.24 v1(93.89,82.73)
  BOTTOM w0.089: v1(93.89,82.73) 93.89,82.59 94.39,82.08 R423.1
  BOTTOM w0.14: v1(35.84,48.54) 35.88,48.59 38.49,48.59 38.77,48.31 38.77,47.81 R540.1 40.57,48.08 U28.15
LPC_LAD3_R: length 7.3
  BOTTOM w0.089: R423.2 v1(94.39,79.93) 94.39,79.63 94.75,79.27 94.75,78.43 94.29,77.98 94.29,75.23 94.45,75.08 94.45,74.87 94.43,74.86 94.34,74.73 94.34,74.58 94.43,74.45 94.62,74.26 U22.C35
LPC_LFRAME#: length 133.4
  TOP w0.14: v1(30.61,38.63) 30.61,37.72 29.68,36.78 27.06,36.78 26.66,36.38 U14.6
  IN1 w0.089: v1(30.61,38.63) 31.05,39.06 31.05,46.41 35.87,51.23 35.87,52.1 v1(35.47,52.5) 35.87,52.9 35.87,55.85 36.86,56.85 36.86,58.17 39.99,61.29 39.99,65.44 40.83,66.28 41.07,66.28 41.07,66.28 45.68,66.28 48.35,68.95 51.11,68.95 51.67,69.5 57.48,69.5 58.78,70.8 61.35,70.8 61.99,71.44 63.84,71.44 65.46,73.06 65.46,77.83 63.84,79.44 63.84,84.19 63.02,85.01 63.02,86.72 68.41,92.1 82.93,92.1 84.4,90.64 97.12,90.64 97.7,90.07 v1(97.7,89.33)
  BOTTOM w0.14: v1(97.7,89.33) 97.49,89.13 97.49,85.83 96.81,85.15 R413.1 ; U28.20 38.14,51.11 37.5,50.47 R534.2 R532.2 37.12,51.86 36.8,52.18 35.78,52.18 v1(35.47,52.5)
LPC_LFRAME#_R: length 9.4
  BOTTOM w0.089: U22.B33 95.53,75.15 95.43,75.25 95.43,75.86 95.99,76.43 95.99,77.34 96.3,77.65 96.3,79.81 96.49,80 96.49,82.03 v1(96.93,82.47)
  BOTTOM w0.14: R413.2 96.81,82.6 v1(96.93,82.47)
LPCPD#: length 2.1
  BOTTOM w0.14: TP56.1 41.82,55.42 41.57,55.17 U28.28
M0_VREF_DQ: length 1.9
  TOP w0.381: v1(96.8,57.94) 97.44,58.58 TP16.1
  BOTTOM w0.089: U22.AY31 96.47,57.61 v1(96.8,57.94)
M1_VREF_CA: length 101.9
  IN2 w0.381: v1(150.15,59.23) 151.01,60.09 151.57,60.09 152.08,59.59 152.08,51.78 153.47,50.39 153.47,39.78 152.72,39.03 v1(152.72,38.73)
  IN3 w0.229: v1(98.78,58.7) 99.25,59.17 99.84,59.17 100.1,58.92 100.1,56.92 100.46,56.56 100.95,56.56 101.07,56.44
  IN3 w0.381: 101.07,56.44 101.08,56.42 101.5,56.01 101.5,53.65 101.85,53.3 101.85,49.28 104.13,47 104.13,43.55 116.45,31.23 128.37,31.23 128.85,30.74 138,30.74 140.63,33.37 141.81,34.55 143.14,34.55 143.42,34.83 146.53,34.83 148.03,36.33 150.32,36.33 v1(152.72,38.73)
  BOTTOM w0.254: v1(98.78,58.7) 98.4,58.32 U22.AV27
  BOTTOM w0.381: R519.2 150.53,58.86 150.52,58.86 v1(150.15,59.23)
M1_VREF_DQ: length 7.8
  TOP w0.127: TP17.1 97.64,53.57 97.96,53.25 98.85,53.25 99.17,53.57 99.17,57.6 v1(98.8,57.96)
  BOTTOM w0.089: U22.AY25 99.18,57.7 v1(98.8,57.96)
M_A_A0: length 41
  IN3 w0.089: v1(89.66,55.03) 89.09,54.47 89.09,53.35 87.91,52.17 87.91,51.17
  IN3 w0.178: v1(83.33,21.95) 83.06,21.95 82.76,22.25 82.76,22.96 82.5,23.22 81.76,23.22 81.57,23.42 81.57,23.75 81.75,23.93 82.72,23.93 84.37,25.59 84.37,30.17 86.23,32.03 86.23,45.43 87.91,47.11 87.91,51.17
  BOTTOM w0.089: U22.BD45 90.1,55.47 v1(89.66,55.03)
  BOTTOM w0.203: v1(83.33,21.95) 83.02,21.65 JDIM1.144
M_A_A1: length 40.4
  IN3 w0.089: 87.53,50.9 87.53,52.43 v1(88.71,53.61)
  IN3 w0.178: v1(82.19,25.61) 82.24,25.61 83.22,26.59 83.22,28.44 83.93,29.16 83.93,31.37 84.11,31.54 84.97,31.54 85.15,31.72 85.15,32.08 84.97,32.25 84.11,32.25 83.93,32.43 83.93,33.29 84.27,33.62 84.52,33.62 85.03,33.11 85.29,33.11 85.54,33.36 85.54,33.61 85.02,34.12 85.02,34.37 85.85,35.2 85.85,47.27 86.05,47.48 86.3,47.48 86.85,46.93 87.1,46.93 87.35,47.19 87.35,47.44 86.81,47.98 86.81,48.23 87.53,48.96 87.53,50.9
  BOTTOM w0.089: v1(88.71,53.61) 88.4,53.61 U22.BH50
  BOTTOM w0.203: v1(82.19,25.61) 82.19,25.61 81.05,26.74 80.88,26.74 80.28,27.35 JDIM1.133
M_A_A2: length 40.5
  IN3 w0.089: 89.11,50.81 89.11,51.89 89.66,52.44 v1(89.66,53.61)
  IN3 w0.178: 89.11,50.81 89.11,46.62 87.63,45.14 87.63,39.61 86.99,38.97 86.99,31.71 85.13,29.86 85.13,24.06 84.08,23.01 84.08,21.87 83.12,20.91 80.68,20.91 v1(80.25,21.35)
  BOTTOM w0.089: U22.BH47 89.22,54.05 v1(89.66,53.61)
  BOTTOM w0.203: JDIM1.132 80.02,21.13 v1(80.25,21.35)
M_A_A3: length 38.5
  IN3 w0.089: 85.99,50.62 85.99,51.26 86.9,52.17 86.9,53.23 v1(87.09,53.42)
  IN3 w0.178: 85.99,50.62 85.99,48.51 85.08,47.61 85.08,35.51 82.33,32.76 82.33,32.51 82.85,31.99 82.85,31.74 82.6,31.49 82.35,31.49 81.83,32.01 81.58,32.01 81.33,31.75 81.33,31.5 81.86,30.97 81.86,30.67 81.65,30.46 81.36,30.46 80.82,31 80.57,31 80.22,30.65 80.22,26.22 v1(80.95,25.5)
  BOTTOM w0.089: v1(87.09,53.42) 87.1,53.44 U22.BG52
  BOTTOM w0.203: JDIM1.131 79.78,26.58 80.86,25.5 v1(80.95,25.5)
M_A_A4: length 42.6
  IN1 w0.127: v1(79.02,21.94) 79.03,21.94 79.03,22.68 79.23,22.88 80.37,22.88 80.5,23.01 80.5,23.26 80.37,23.39 79.28,23.39 79.03,23.65 79.03,24.33 79.42,24.72 83.68,24.72 84.82,25.86 84.82,41.83 v1(86.7,43.71)
  BOTTOM w0.089: U22.BK45 90.12,51.14 89.8,50.82 89.8,50.34 89.62,50.16 89.62,49.71
  BOTTOM w0.203: v1(86.7,43.71) 86.65,43.71 86.21,44.15 86.21,46.31 89.62,49.71 ; JDIM1.128 v1(79.02,21.94)
M_A_A5: length 43.1
  IN1 w0.127: v1(78.02,22.89) 78.7,23.56 78.7,26.74 82.78,30.83 83.47,30.83 83.6,30.96 83.6,31.21 83.47,31.34 82.71,31.34 82.58,31.47 82.58,31.72 82.71,31.85 83.47,31.85 83.6,31.97 83.6,32.23 83.47,32.36 82.71,32.36 82.58,32.48 82.58,32.74 82.71,32.86 83.47,32.86 83.6,32.99 83.6,33.24 83.47,33.37 82.76,33.37 82.58,33.55 82.58,37.44 83.67,38.53 v1(83.67,40.38)
  BOTTOM w0.089: 88.86,50.1 88.86,50.26 89.19,50.6 89.19,51.31 89.14,51.35 89.14,51.62 89.22,51.7 89.22,51.7 89.39,51.87 89.39,52.42 89.5,52.59 89.5,52.71 U22.BJ46
  BOTTOM w0.203: 88.86,50.1 85.4,46.65 85.4,41.98 83.8,40.38 v1(83.67,40.38) ; JDIM1.126 78.53,22.39 v1(78.02,22.89)
M_A_A6: length 42.7
  IN1 w0.127: v1(86.7,44.98) 86.38,44.66 86.2,44.66 85.44,45.42 85.23,45.42 85.08,45.27 85.08,45.06 85.84,44.3 85.84,44.12 85.66,43.94 85.48,43.94 84.68,44.74 84.47,44.74 84.32,44.59 84.32,44.38 85.12,43.58 85.12,43.4 84.49,42.77 84.49,26 83.57,25.08 80.21,25.08 v1(79.28,26.01)
  BOTTOM w0.089: 90.03,49.73 90.03,50.68 90.3,50.95 90.3,52.02 90.29,52.23 90.29,52.44 90.34,52.49 U22.BJ44
  BOTTOM w0.203: v1(79.28,26.01) 78.85,26.44 78.85,27.28 78.78,27.35 JDIM1.127 ; 90.03,49.73 90.03,49.55 86.7,46.22 v1(86.7,44.98)
M_A_A7: length 42.7
  IN1 w0.127: v1(78.01,24.38) 77.35,25.04 77.35,26.87 79.84,29.36 79.84,33.93 80.09,34.18 81.44,34.18 81.57,34.31 81.57,34.56 81.44,34.69 79.97,34.69 79.84,34.82 79.84,35.07 79.97,35.2 81.41,35.2 81.54,35.33 81.54,37.72 82.73,38.91 82.73,41.98 v1(83.67,42.92)
  BOTTOM w0.089: 88,50.39 88.17,50.57 88.63,51.03 88.78,51.18 88.78,51.77 89.04,52.02 89.04,52.43 89.02,52.44 88.92,52.59 88.92,52.71 89.02,52.86 89.21,53.05 U22.BJ47
  BOTTOM w0.203: JDIM1.122 77.53,23.9 v1(78.01,24.38) ; 88,50.39 84.59,46.98 84.59,43.74 83.78,42.92 v1(83.67,42.92)
M_A_A8: length 43.4
  IN1 w0.127: v1(86.7,42.44) 85.15,40.89 85.15,25.73 83.82,24.39 82.73,24.39 82.6,24.27 82.6,23.46 82.45,23.32 82.24,23.32 82.1,23.46 82.1,24.27 81.97,24.39 79.91,24.39 v1(79.52,24)
  BOTTOM w0.089: U22.BJ45 89.9,52.82 89.88,52.79 89.84,52.72 89.84,52.6 89.88,52.51 89.94,52.43 89.94,51.31 89.52,50.89 89.52,50.44 89.29,50.22 89.29,49.96
  BOTTOM w0.203: v1(86.7,42.44) 86.54,42.44 85.81,43.18 85.81,46.48 89.29,49.96 ; JDIM1.125 78.28,27.34 78.48,27.14 78.48,25.04 v1(79.52,24)
M_A_A9: length 42.4
  IN1 w0.127: v1(78.02,26.95) 80.32,29.24 80.32,30.17 80.56,30.41 81.72,30.41 81.87,30.56 81.87,30.77 81.72,30.92 80.45,30.92 80.32,31.05 80.32,31.3 80.45,31.43 81.98,31.43 82.12,31.58 82.12,31.79 81.98,31.94 80.45,31.94 80.32,32.06 80.32,32.32 80.45,32.45 81.93,32.45 82.07,32.59 82.07,32.81 81.93,32.95 80.45,32.95 80.32,33.08 80.32,33.33 80.45,33.46 81.86,33.46 82.07,33.68 82.07,37.64 83.17,38.73 83.17,41.15 v1(83.67,41.65)
  BOTTOM w0.089: 88.33,50.15 88.96,50.78 88.96,51.69 88.98,51.71 88.98,51.71 89.21,51.94 U22.BK47
  BOTTOM w0.203: v1(78.02,26.95) 77.52,26.95 77.28,27.19 JDIM1.121 ; v1(83.67,41.65) 83.83,41.65 85,42.82 85,46.82 88.33,50.15
M_A_A10: length 38.9
  IN3 w0.089: v1(89.66,54.32) 89.51,54.32 89.27,54.08 89.27,52.53 88.83,52.09 88.83,51.08 88.73,50.98 88.73,50.72
  IN3 w0.178: 88.73,50.72 88.73,46.78 87.25,45.3 87.25,39.77 86.61,39.13 86.61,31.87 84.75,30.01 84.75,24.27 83.72,23.24 v1(83.3,23.24)
  BOTTOM w0.089: U22.BF45 90.1,54.76 v1(89.66,54.32)
  BOTTOM w0.203: JDIM1.146 85.53,21.11 85,21.64 83.4,23.24 v1(83.3,23.24)
M_A_A11: length 40.1
  IN1 w0.127: v1(76.53,22.18) 74.66,24.05 74.66,27.4 75.37,28.12 75.37,30.57 75.24,30.69 74.86,30.69 74.73,30.82 74.73,31.07 74.86,31.2 75.24,31.2 75.37,31.33 75.37,32.48 76.87,33.98 76.87,35.91 80.14,39.19 80.14,43.36 v1(80.65,43.86)
  BOTTOM w0.089: U22.BJ51 87.32,52.46 87.28,52.33 87.28,52.17 87.08,51.97 87.02,51.97 86.38,51.33
  BOTTOM w0.203: 86.38,51.33 82.89,47.83 82.89,46.1 v1(80.65,43.86) ; v1(76.53,22.18) 77.02,21.68 JDIM1.120
M_A_A12: length 39.9
  IN1 w0.127: v1(80.65,45.18) 81.07,44.77 81.07,42.76 80.75,42.44 80.75,39.01 77.35,35.61 77.35,33.02 77.22,32.89 76.71,32.89 76.59,32.76 76.59,32.51 76.71,32.38 77.22,32.38 77.35,32.26 77.35,32 77.22,31.87 76.71,31.87 76.59,31.75 76.59,31.49 76.71,31.37 77.22,31.37 77.35,31.24 77.35,30.99 77.22,30.86 76.71,30.86 76.59,30.73 76.59,28.4 75.52,27.33 75.52,25.82 v1(75.13,25.43)
  BOTTOM w0.089: U22.BJ52 86.86,52.65 86.67,52.47 86.67,52.19 86.01,51.53
  BOTTOM w0.203: 86.01,51.53 82.48,48 82.48,46.85 80.81,45.18 v1(80.65,45.18) ; JDIM1.119 76.8,28.24 76.8,25.79 76.43,25.43 v1(75.13,25.43)
