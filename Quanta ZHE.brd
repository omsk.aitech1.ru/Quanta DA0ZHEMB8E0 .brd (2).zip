# Allegro board Quanta ZHE.brd (continued)
## Nets (continued)
HDMI_HPD_C: R79.1 R437.2
HDMI_HPD_DC: R78.1 R79.2 U6.40(HPD_SRC)
HDMI_RST#: C39.2 R60.2 U6.35(RESETB)
HDMI_SCLK: C9.1 CN1.15(SCL) R390.2 R627.2 R628.2
HDMI_SCLK_R: R627.1 U6.7(SCL_SNK)
HDMI_SDATA: C8.1 CN1.16(SDA) R395.2 R626.2 R629.2
HDMI_SDATA_R: R626.1 U6.8(SDA_SNK)
HDMI_SEL#_A1: R42.2 U6.32(HDMI_ID)
HP-L2: L3.1 U16.32(HP-OUT-L)
HP-L3: C213.2 L3.2 R215.2 R226.1
HP-L4: C195.2 CN8.1(L) R215.1
HP-R2: L1.1 U16.33(HP-OUT-R)
HP-R3: C185.2 L1.2 R203.1 R204.2
HP-R4: C190.2 CN8.2(R) R204.1
HP_JD#: CN8.6 D16.1 R340.2
HWPG: D8.2(ANODE) D9.2(ANODE) D10.2(ANODE) D11.2(ANODE) D14.2(ANODE) D18.2(ANODE) D21.2(ANODE) D22.2(ANODE) R302.1 U14.21(RI2#/GPD1)
HWPG_1.2VSUS: D18.1(CATHODE) PR244.2 PR245.2
HWPG_1.05V: D11.1(CATHODE) PR7.2 PR9.2
HWPG_1.5V: D21.1(CATHODE) PR218.2 PU12.1(POK)
HWPG_1.05V_EC#: R225.1 U14.122(DTR1/SBUSY/GPG1/ID7)
HWPG_1.8V_S5: D9.1(CATHODE) PR148.1 PR215.2 PR220.2
HWPG_1.24V_S5: D14.1(CATHODE) PR143.2 PR147.2
HWPG_2.5V: D22.1(CATHODE) PR109.1 PR114.2
I2C_4_SCL_R: Q20.1(S) R100.2 U22.R49(SIO_I2C4_SCL)
I2C_4_SDA_R: Q20.4(S) R104.2 U22.R51(SIO_I2C4_SDA)
I2C_SEL_PIN: R39.2 U6.31(I2C_ADDR)
I2C_TP_SCL_R: CN12.6 Q20.6(D) R369.1
I2C_TP_SDA_R: CN12.5 Q20.3(D) R359.1
ICMNT: C261.2 PC111.2 PR124.2 U14.67(ADC1/GPI1)
IERR: R486.1 U22.W53(GPIO_40)
IMVP_PWRGD: D10.1(CATHODE) PR151.2 PR156.2
IMVP_PWRGD_VNN: D8.1(CATHODE) PR25.2 PR175.2
INT_AMIC-VREFO: C263.1 R320.2 U16.27(LDO1-CAP)
INT_EDP_HPD#: Q4.3(D) R56.1 U22.B39(EDP_HPD)
INT_HDMI_HPD#: Q30.3(D) R409.1 U22.C39(DDI0_HPD)
INT_HDMICLK+: C71.2 U22.AG2(DDI0_TXP_3)
INT_HDMICLK-: C72.2 U22.AG3(DDI0_TXN_3)
INT_HDMITX0N: C57.2 U22.AJ3(DDI0_TXN_2)
INT_HDMITX0P: C56.2 U22.AJ2(DDI0_TXP_2)
INT_HDMITX1N: C70.2 U22.AE3(DDI0_TXN_1)
INT_HDMITX1P: C69.2 U22.AE2(DDI0_TXP_1)
INT_HDMITX2N: C55.2 U22.AH3(DDI0_TXN_0)
INT_HDMITX2P: C54.2 U22.AH1(DDI0_TXP_0)
INTRUDER#: R52.1 U22.H25(INTRUDER)
IOAC_LAN_WAKE#: R36.2 U14.87(PS2CLK1/DTR0#/GPF2)
IOAC_RST#: R23.1 R287.1 R636.1 U14.85(PS2CLK0/TMB0/CEC/GPF0)
IOAC_WIGIG_RST#: R278.1 U14.2(GPJ7)
IOAC_WLAN_WAKE#: R592.1 U14.16(PWUREQ#/BBO/GPC7)
IRQ_SERIRQ: R207.1 R270.1 U10.3(A) U14.5(SERIRQ/GPM6)
ISEN1N_VCGI: PC177.1 PC182.1 PR135.2 PR136.2 PR194.2 PU10.21(ISEN1N)
ISEN1N_VNN: PC47.1 PC49.1 PR11.2 PR51.2 PR134.2 PU1.21(ISEN1N)
ISEN1P_VCGI: PC177.2 PR182.2 PR183.1 PU10.20(ISEN1P)
ISEN1P_VNN: PC49.2 PR41.2 PR47.1 PU1.20(ISEN1P)
ISOLATEB: R25.1 R26.2 U3.20(ISOLATEB)
KB_BL_LED: Q27.2(BASE) R548.2
KB_BL_LED_R: R548.1 U14.113(CRX0/GPC0)
L_SPK+: R378.2 U16.42(SPK-L+)
L_SPK+_CN: C326.1 CN17.4 R378.1
L_SPK-: R379.2 U16.43(SPK-L-)
L_SPK-_CN: C327.1 CN17.3 R379.1
LAD0_C: CN10.64(GPIO0_NFC_RESET#) R517.2
LAD1_C: CN10.66(UIM_SWP/PERST1#) R530.2
LAD2_C: CN10.68(UIM_POWER_SNK) R537.2
LAD3_C: CN10.70(UIM_POWER_SRC) R540.2
LAN_MCT0: R29.1 U20.24(NC #4)
LAN_MCT1: R24.1 U20.21(NC #3)
LAN_MCT2: R21.1 U20.18(NC #2)
LAN_MCT3: R11.1 U20.15(NC #1)
LAN_MX0+: CN4.1 U20.23(MX1+)
LAN_MX0-: CN4.2 U20.22(MX1-)
LAN_MX1+: CN4.3 U20.20(MX2+)
LAN_MX1-: CN4.6 U20.19(MX2-)
LAN_MX2+: CN4.4 U20.17(MX3+)
LAN_MX2-: CN4.5 U20.16(MX3-)
LAN_MX3+: CN4.7 U20.14(MX4+)
LAN_MX3-: CN4.8 U20.13(MX4-)
LANCT3: C3.1 R11.2 R21.2 R24.2 R29.2
LANPWR#: R93.2 U14.70(ADC4/GPI4)
LANVCC: C4.2 C6.1 C18.1 C19.2 Q1.2(BASE) R2.1 R50.2 R64.2 U3.11(AVDD33#1) U3.32(AVDD33#2)
LCDVCC: C34.2 C35.1 C37.1 CN5.5 CN5.6 CN5.7 R54.1 R63.1
LFRAME#_C: CN10.73(RESERVED2) R532.1
LGATE_VCGI: PQ16.4(G) PU10.11(LGATE)
LGATE_VNN: PQ15.4(G) PU1.11(LGATE)
LGND: C1.1 C2.2 C3.2 CN4.9 CN4.10 CN4.11 CN4.12 R1.1 R20.1
LID#: D5.1(CATHODE) D30.2 HE1.1(OUTPUT) R125.2 R384.2 R549.2
LID#_R: D40.1 R549.1 U14.118(SMDAT2/PECIRQT#/GPF7)
LINE1-L: C213.1 U16.22(LINE1-L)
LINE1-R: C185.1 U16.21(LINE1-R)
LINE1-VREFO-L: R226.2 U16.31(LINE1-VREFO-L)
LINE1-VREFO-R: R203.2 U16.30(LINE1-VREFO-R)
LPC_CLKOUT0: R441.2 U22.C37(LPC_CLKOUT0)
LPC_CLKOUT1: R421.2 R440.2 U22.A38(LPC_CLKOUT1)
LPC_CLKRUN#_R: R424.2 U22.C33(L\P\C\_\C\L\K\R\U\N\)
LPC_LAD0: R412.1 R517.1 R522.1 U14.10(LAD0) U28.24(LAD0/MISO)
LPC_LAD0_R: R412.2 U22.A34(LPC_AD0)
LPC_LAD1: R442.1 R530.1 U14.9(LAD1) U28.21(LAD1/MOSI)
LPC_LAD1_R: R442.2 U22.C34(LPC_AD1)
LPC_LAD2: R411.1 R537.1 U14.8(LAD2) U28.18(LAD2/S\P\I\_\I\R\Q\)
LPC_LAD2_R: R411.2 U22.B35(LPC_AD2)
LPC_LAD3: R423.1 R540.1 U14.7(LAD3) U28.15(LAD3)
LPC_LAD3_R: R423.2 U22.C35(LPC_AD3)
LPC_LFRAME#: R413.1 R532.2 R534.2 U14.6(LFRAME#/GPM5) U28.20(L\F\R\A\M\E\/S\C\S\)
LPC_LFRAME#_R: R413.2 U22.B33(L\P\C\_\F\R\A\M\E\)
LPCPD#: TP56.1 U28.28(L\P\C\P\D\)
M0_VREF_DQ: TP16.1 U22.AY31(MEM_CH0_VREFDQ)
M1_VREF_CA: R519.2 U22.AV27(MEM_CH1_VREFCA)
M1_VREF_DQ: TP17.1 U22.AY25(MEM_CH1_VREFDQ)
M_A_A0: JDIM1.144(A0) U22.BD45(MEM_CH0_MA0)
M_A_A1: JDIM1.133(A1) U22.BH50(MEM_CH0_MA1)
M_A_A2: JDIM1.132(A2) U22.BH47(MEM_CH0_MA2)
M_A_A3: JDIM1.131(A3) U22.BG52(MEM_CH0_MA3)
M_A_A4: JDIM1.128(A4) U22.BK45(MEM_CH0_MA4)
M_A_A5: JDIM1.126(A5) U22.BJ46(MEM_CH0_MA5)
M_A_A6: JDIM1.127(A6) U22.BJ44(MEM_CH0_MA6)
M_A_A7: JDIM1.122(A7) U22.BJ47(MEM_CH0_MA7)
M_A_A8: JDIM1.125(A8) U22.BJ45(MEM_CH0_MA8)
M_A_A9: JDIM1.121(A9) U22.BK47(MEM_CH0_MA9)
M_A_A10: JDIM1.146(A10/AP) U22.BF45(MEM_CH0_MA10)
M_A_A11: JDIM1.120(A11) U22.BJ51(MEM_CH0_MA11)
M_A_A12: JDIM1.119(A12) U22.BJ52(MEM_CH0_MA12)
M_A_A13: JDIM1.158(A13) U22.BH43(MEM_CH0_MA13)
M_A_ACT#: JDIM1.114(ACT#) U22.BF41(M\E\M\_\C\H\0\_\A\C\T\)
M_A_ALERT#: JDIM1.116(ALERT#) R330.2
M_A_BA#0: JDIM1.150(BA0) U22.BD43(MEM_CH0_BA0)
M_A_BA#1: JDIM1.145(BA1) U22.BH51(MEM_CH0_BA1)
M_A_BG#0: JDIM1.115(BG0) U22.BL50(MEM_CH0_BG0)
M_A_BG#1: JDIM1.113(BG1) U22.BF43(MEM_CH0_BG1)
M_A_CAS#: JDIM1.156(A15/CAS#) U22.BJ50(MEM_CH0_MA15)
M_A_CB0: JDIM1.92(CB0) R327.2
M_A_CB1: JDIM1.91(CB1) R304.2
M_A_CB2: JDIM1.101(CB2) R307.2
M_A_CB3: JDIM1.105(CB3) R308.2
M_A_CB4: JDIM1.88(CB4) R326.2
M_A_CB5: JDIM1.87(CB5) R303.2
M_A_CB6: JDIM1.100(CB6) R328.2
M_A_CB7: JDIM1.104(CB7) R329.2
M_A_CKE0: JDIM1.109(CKE0) U22.BF55(MEM_CH0_CKE0)
M_A_CKE1: JDIM1.110(CKE1) U22.BF54(MEM_CH0_CKE1)
M_A_CLK0: JDIM1.137(CK0) U22.BE49(MEM_CH0_CLK0_P)
M_A_CLK0#: JDIM1.139(CK0#) U22.BE51(M\E\M\_\C\H\0\_\C\L\K\0\)
M_A_CLK1: JDIM1.138(CK1) U22.BC49(MEM_CH0_CLK1_P)
M_A_CLK1#: JDIM1.140(CK1#) U22.BC48(M\E\M\_\C\H\0\_\C\L\K\1\)
M_A_CS#0: JDIM1.149(CS0#) U22.BJ43(M\E\M\_\C\H\0\_\C\S\0\)
M_A_CS#1: JDIM1.157(CS1#) U22.BK43(M\E\M\_\C\H\0\_\C\S\1\)
M_A_DQ0: JDIM1.8(DQ0) U22.AR53(MEM_CH0_DQ0)
M_A_DQ1: JDIM1.7(DQ1) U22.AP55(MEM_CH0_DQ1)
M_A_DQ2: JDIM1.3(DQ5) U22.AP53(MEM_CH0_DQ2)
M_A_DQ3: JDIM1.4(DQ4) U22.AN54(MEM_CH0_DQ3)
M_A_DQ4: JDIM1.20(DQ2) U22.AU54(MEM_CH0_DQ4)
M_A_DQ5: JDIM1.16(DQ6) U22.AV53(MEM_CH0_DQ5)
M_A_DQ6: JDIM1.21(DQ3) U22.AV55(MEM_CH0_DQ6)
M_A_DQ7: JDIM1.17(DQ7) U22.AW53(MEM_CH0_DQ7)
M_A_DQ8: JDIM1.67(DQ29) U22.AU51(MEM_CH0_DQ8)
M_A_DQ9: JDIM1.66(DQ28) U22.AU48(MEM_CH0_DQ9)
M_A_DQ10: JDIM1.71(DQ25) U22.AU49(MEM_CH0_DQ10)
M_A_DQ11: JDIM1.84(DQ27) U22.BA46(MEM_CH0_DQ11)
M_A_DQ12: JDIM1.83(DQ26) U22.BA48(MEM_CH0_DQ12)
M_A_DQ13: JDIM1.80(DQ31) U22.BA49(MEM_CH0_DQ13)
M_A_DQ14: JDIM1.79(DQ30) U22.BA51(MEM_CH0_DQ14)
M_A_DQ15: JDIM1.70(DQ24) U22.AR51(MEM_CH0_DQ15)
M_A_DQ16: JDIM1.50(DQ16) U22.AY55(MEM_CH0_DQ16)
M_A_DQ17: JDIM1.45(DQ21) U22.BA54(MEM_CH0_DQ17)
M_A_DQ18: JDIM1.49(DQ17) U22.BA53(MEM_CH0_DQ18)
M_A_DQ19: JDIM1.46(DQ20) U22.AY53(MEM_CH0_DQ19)
M_A_DQ20: JDIM1.62(DQ18) U22.BC53(MEM_CH0_DQ20)
M_A_DQ21: JDIM1.58(DQ22) U22.BD55(MEM_CH0_DQ21)
M_A_DQ22: JDIM1.63(DQ19) U22.BE54(MEM_CH0_DQ22)
M_A_DQ23: JDIM1.59(DQ23) U22.BD53(MEM_CH0_DQ23)
M_A_DQ24: JDIM1.28(DQ8) U22.AN43(MEM_CH0_DQ24)
M_A_DQ25: JDIM1.24(DQ12) U22.AN44(MEM_CH0_DQ25)
M_A_DQ26: JDIM1.42(DQ11) U22.AR48(MEM_CH0_DQ26)
M_A_DQ27: JDIM1.41(DQ10) U22.AU41(MEM_CH0_DQ27)
M_A_DQ28: JDIM1.37(DQ15) U22.AU43(MEM_CH0_DQ28)
M_A_DQ29: JDIM1.25(DQ13) U22.AN41(MEM_CH0_DQ29)
M_A_DQ30: JDIM1.29(DQ9) U22.AN39(MEM_CH0_DQ30)
M_A_DQ31: JDIM1.38(DQ14) U22.AU44(MEM_CH0_DQ31)
M_A_DQ32: JDIM1.182(DQ39) U22.BA35(MEM_CH0_DQ32)
M_A_DQ33: JDIM1.187(DQ34) U22.AY33(MEM_CH0_DQ33)
M_A_DQ34: JDIM1.183(DQ38) U22.BA33(MEM_CH0_DQ34)
M_A_DQ35: JDIM1.186(DQ35) U22.AY35(MEM_CH0_DQ35)
M_A_DQ36: JDIM1.173(DQ33) U22.BA37(MEM_CH0_DQ36)
M_A_DQ37: JDIM1.169(DQ37) U22.AY37(MEM_CH0_DQ37)
M_A_DQ38: JDIM1.174(DQ32) U22.AY39(MEM_CH0_DQ38)
M_A_DQ39: JDIM1.170(DQ36) U22.BA39(MEM_CH0_DQ39)
M_A_DQ40: JDIM1.208(DQ43) U22.BJ36(MEM_CH0_DQ40)
M_A_DQ41: JDIM1.203(DQ46) U22.BK37(MEM_CH0_DQ41)
M_A_DQ42: JDIM1.207(DQ42) U22.BJ35(MEM_CH0_DQ42)
M_A_DQ43: JDIM1.204(DQ47) U22.BL36(MEM_CH0_DQ43)
M_A_DQ44: JDIM1.195(DQ40) U22.BJ39(MEM_CH0_DQ44)
M_A_DQ45: JDIM1.190(DQ45) U22.BL40(MEM_CH0_DQ45)
M_A_DQ46: JDIM1.194(DQ41) U22.BJ40(MEM_CH0_DQ46)
M_A_DQ47: JDIM1.191(DQ44) U22.BK41(MEM_CH0_DQ47)
M_A_DQ48: JDIM1.225(DQ55) U22.BD29(MEM_CH0_DQ48)
M_A_DQ49: JDIM1.228(DQ50) U22.BF29(MEM_CH0_DQ49)
M_A_DQ50: JDIM1.224(DQ54) U22.BH29(MEM_CH0_DQ50)
M_A_DQ51: JDIM1.215(DQ49) U22.BF33(MEM_CH0_DQ51)
M_A_DQ52: JDIM1.229(DQ51) U22.BC29(MEM_CH0_DQ52)
M_A_DQ53: JDIM1.211(DQ52) U22.BD33(MEM_CH0_DQ53)
M_A_DQ54: JDIM1.212(DQ53) U22.BF35(MEM_CH0_DQ54)
M_A_DQ55: JDIM1.216(DQ48) U22.BH35(MEM_CH0_DQ55)
M_A_DQ56: JDIM1.232(DQ60) U22.BL34(MEM_CH0_DQ56)
M_A_DQ57: JDIM1.249(DQ58) U22.BL30(MEM_CH0_DQ57)
M_A_DQ58: JDIM1.250(DQ59) U22.BJ29(MEM_CH0_DQ58)
M_A_DQ59: JDIM1.246(DQ63) U22.BK29(MEM_CH0_DQ59)
M_A_DQ60: JDIM1.237(DQ56) U22.BJ33(MEM_CH0_DQ60)
M_A_DQ61: JDIM1.233(DQ61) U22.BK33(MEM_CH0_DQ61)
M_A_DQ62: JDIM1.236(DQ57) U22.BJ34(MEM_CH0_DQ62)
M_A_DQ63: JDIM1.245(DQ62) U22.BJ30(MEM_CH0_DQ63)
M_A_DQSN0: JDIM1.11(DQS#0) U22.AT55(M\E\M\_\C\H\0\_\D\Q\S\0\)
M_A_DQSN1: JDIM1.74(DQS#3) U22.AW48(M\E\M\_\C\H\0\_\D\Q\S\1\)
M_A_DQSN2: JDIM1.53(DQS#2) U22.BB53(M\E\M\_\C\H\0\_\D\Q\S\2\)
M_A_DQSN3: JDIM1.32(DQS#1) U22.AR43(M\E\M\_\C\H\0\_\D\Q\S\3\)
M_A_DQSN4: JDIM1.177(DQS#4) U22.AV35(M\E\M\_\C\H\0\_\D\Q\S\4\)
M_A_DQSN5: JDIM1.198(DQS#5) U22.BJ38(M\E\M\_\C\H\0\_\D\Q\S\5\)
M_A_DQSN6: JDIM1.219(DQS#6) U22.BD31(M\E\M\_\C\H\0\_\D\Q\S\6\)
M_A_DQSN7: JDIM1.240(DQS#7) U22.BK31(M\E\M\_\C\H\0\_\D\Q\S\7\)
M_A_DQSN8: JDIM1.95(DQS#8) R305.2
M_A_DQSP0: JDIM1.13(DQS0) U22.AT53(MEM_CH0_DQS0_P)
M_A_DQSP1: JDIM1.76(DQS3) U22.AW49(MEM_CH0_DQS1_P)
M_A_DQSP2: JDIM1.55(DQS2) U22.BC54(MEM_CH0_DQS2_P)
M_A_DQSP3: JDIM1.34(DQS1) U22.AR41(MEM_CH0_DQS3_P)
M_A_DQSP4: JDIM1.179(DQS4) U22.AV37(MEM_CH0_DQS4_P)
M_A_DQSP5: JDIM1.200(DQS5) U22.BL38(MEM_CH0_DQS5_P)
M_A_DQSP6: JDIM1.221(DQS6) U22.BF31(MEM_CH0_DQS6_P)
M_A_DQSP7: JDIM1.242(DQS7) U22.BJ32(MEM_CH0_DQS7_P)
M_A_DQSP8: JDIM1.97(DQS8) R306.2
M_A_DRAMRST#: C187.1 C280.2 JDIM1.108(RESET#) R196.1 R625.2
M_A_EVENT#: JDIM1.134(EVENT#) R332.2
M_A_ODT0_DIMM: JDIM1.155(O\D\T\0\) U22.BD39(MEM_CH0_ODT0)
M_A_ODT1_DIMM: JDIM1.161(ODT1) U22.BF39(MEM_CH0_ODT1)
M_A_PARITY: JDIM1.143(PARITY) R309.2
M_A_RAS#: JDIM1.152(A16/RAS#) U22.BD41(MEM_CH0_MA16)
M_A_WE#: JDIM1.151(A14/WE#) U22.BJ48(MEM_CH0_MA14)
M_B1_ZQ0: R145.1 U9.F9(ZQ)
M_B2_ZQ0: R193.1 U25.F9(ZQ)
M_B3_ZQ0: R243.1 U13.F9(ZQ)
M_B4_ZQ0: R556.1 U30.F9(ZQ)
M_B_A0: R228.2 U9.P3(A0) U13.P3(A0) U22.BH9(MEM_CH1_MA0) U25.P3(A0) U30.P3(A0)
M_B_A1: R239.2 U9.P7(A1) U13.P7(A1) U22.BC13(MEM_CH1_MA1) U25.P7(A1) U30.P7(A1)
M_B_A2: R240.2 U9.R3(A2) U13.R3(A2) U22.BD11(MEM_CH1_MA2) U25.R3(A2) U30.R3(A2)
M_B_A3: R252.2 U9.N7(A3) U13.N7(A3) U22.BD13(MEM_CH1_MA3) U25.N7(A3) U30.N7(A3)
M_B_A4: R210.2 U9.N3(A4) U13.N3(A4) U22.BJ4(MEM_CH1_MA4) U25.N3(A4) U30.N3(A4)
M_B_A5: R220.2 U9.P8(A5) U13.P8(A5) U22.BL6(MEM_CH1_MA5) U25.P8(A5) U30.P8(A5)
M_B_A6: R211.2 U9.P2(A6) U13.P2(A6) U22.BJ5(MEM_CH1_MA6) U25.P2(A6) U30.P2(A6)
M_B_A7: R230.2 U9.R8(A7) U13.R8(A7) U22.BJ9(MEM_CH1_MA7) U25.R8(A7) U30.R8(A7)
M_B_A8: R214.2 U9.R2(A8) U13.R2(A8) U22.BJ6(MEM_CH1_MA8) U25.R2(A8) U30.R2(A8)
M_B_A9: R241.2 U9.R7(A9) U13.R7(A9) U22.BJ8(MEM_CH1_MA9) U25.R7(A9) U30.R7(A9)
M_B_A10: R238.2 U9.M3(A10/AP) U13.M3(A10/AP) U22.BF11(MEM_CH1_MA10) U25.M3(A10/AP) U30.M3(A10/AP)
M_B_A11: R244.2 U9.T2(A11) U13.T2(A11) U22.BK11(MEM_CH1_MA11) U25.T2(A11) U30.T2(A11)
M_B_A12: R235.2 U9.M7(A12/B\C\) U13.M7(A12/B\C\) U22.BJ12(MEM_CH1_MA12) U25.M7(A12/B\C\) U30.M7(A12/B\C\)
M_B_A13: R213.2 U9.T8(A13) U13.T8(A13) U22.BE5(MEM_CH1_MA13) U25.T8(A13) U30.T8(A13)
M_B_A14: R237.2 U9.L2(WE_N/A14) U13.L2(WE_N/A14) U22.BK9(MEM_CH1_MA14) U25.L2(WE_N/A14) U30.L2(WE_N/A14)
M_B_A15: R231.2 U9.M8(CAS_N/A15) U13.M8(CAS_N/A15) U22.BJ11(MEM_CH1_MA15) U25.M8(CAS_N/A15) U30.M8(CAS_N/A15)
M_B_A16: R209.2 U9.L8(RAS_N/A16) U13.L8(RAS_N/A16) U22.BH5(MEM_CH1_MA16) U25.L8(RAS_N/A16) U30.L8(RAS_N/A16)
M_B_ACT#: R208.2 U9.L3(ACT_N) U13.L3(ACT_N) U22.BE7(M\E\M\_\C\H\1\_\A\C\T\) U25.L3(ACT_N) U30.L3(ACT_N)
M_B_ALERT#: R536.1 U9.P9(ALERT_N) U13.P9(ALERT_N) U25.P9(ALERT_N) U30.P9(ALERT_N)
M_B_BA#0: R217.2 U9.N2(BA0) U13.N2(BA0) U22.BH6(MEM_CH1_BA0) U25.N2(BA0) U30.N2(BA0)
M_B_BA#1: R253.2 U9.N8(BA1) U13.N8(BA1) U22.BF13(MEM_CH1_BA1) U25.N8(BA1) U30.N8(BA1)
M_B_BG#0: R224.2 U9.M2(BG0) U13.M2(BG0) U22.BJ10(MEM_CH1_BG0) U25.M2(BG0) U30.M2(BG0)
M_B_BG#1: R146.1 R265.2 R272.1 R535.1 R558.1 U22.BG4(MEM_CH1_BG1)
M_B_BG#1_1: R146.2 R147.1 U9.M9(VSS#M9)
M_B_BG#1_2: R533.1 R535.2 U25.M9(VSS#M9)
M_B_BG#1_3: R264.1 R272.2 U13.M9(VSS#M9)
M_B_BG#1_4: R557.1 R558.2 U30.M9(VSS#M9)
M_B_CKE0: R246.2 U9.K2(CKE) U13.K2(CKE) U22.BK13(MEM_CH1_CKE0) U25.K2(CKE) U30.K2(CKE)
M_B_CLK0: R219.2 R229.1 U9.K7(CK_T) U13.K7(CK_T) U22.BF17(MEM_CH1_CLK0_P) U25.K7(CK_T) U30.K7(CK_T)
M_B_CLK0#: R218.2 R229.2 U9.K8(CK_C) U13.K8(CK_C) U22.BD17(M\E\M\_\C\H\1\_\C\L\K\0\) U25.K8(CK_C) U30.K8(CK_C)
M_B_CS#0: R223.2 U9.L7(C\S\) U13.L7(C\S\) U22.BH2(M\E\M\_\C\H\1\_\C\S\0\) U25.L7(C\S\) U30.L7(C\S\)
M_B_DQ0: U22.BJ26(MEM_CH1_DQ0) U30.B8(DQU1)
M_B_DQ1: U22.BL26(MEM_CH1_DQ1) U30.C7(DQU3)
M_B_DQ2: U22.BJ27(MEM_CH1_DQ2) U30.C8(DQU5)
M_B_DQ3: U22.BK27(MEM_CH1_DQ3) U30.D7(DQU7)
M_B_DQ4: U22.BJ23(MEM_CH1_DQ4) U30.D3(DQU6)
M_B_DQ5: U22.BK23(MEM_CH1_DQ5) U30.C2(DQU4)
M_B_DQ6: U22.BJ22(MEM_CH1_DQ6) U30.C3(DQU2)
M_B_DQ7: U22.BL22(MEM_CH1_DQ7) U30.A3(DQU0)
M_B_DQ8: U22.BD27(MEM_CH1_DQ8) U30.J7(DQL7)
M_B_DQ9: U22.BF27(MEM_CH1_DQ9) U30.F7(DQL1)
M_B_DQ10: U22.BH27(MEM_CH1_DQ10) U30.H7(DQL3)
M_B_DQ11: U22.BC27(MEM_CH1_DQ11) U30.H8(DQL5)
M_B_DQ12: U22.BH21(MEM_CH1_DQ12) U30.H2(DQL4)
M_B_DQ13: U22.BF23(MEM_CH1_DQ13) U30.J3(DQL6)
M_B_DQ14: U22.BD23(MEM_CH1_DQ14) U30.H3(DQL2)
M_B_DQ15: U22.BF21(MEM_CH1_DQ15) U30.G2(DQL0)
M_B_DQ16: U13.H2(DQL4) U22.BK19(MEM_CH1_DQ16)
M_B_DQ17: U13.J3(DQL6) U22.BJ20(MEM_CH1_DQ17)
M_B_DQ18: U13.G2(DQL0) U22.BL20(MEM_CH1_DQ18)
M_B_DQ19: U13.H3(DQL2) U22.BJ21(MEM_CH1_DQ19)
M_B_DQ20: U13.F7(DQL1) U22.BJ17(MEM_CH1_DQ20)
M_B_DQ21: U13.H8(DQL5) U22.BJ16(MEM_CH1_DQ21)
M_B_DQ22: U13.H7(DQL3) U22.BK15(MEM_CH1_DQ22)
M_B_DQ23: U13.J7(DQL7) U22.BL16(MEM_CH1_DQ23)
M_B_DQ24: U13.C3(DQU2) U22.BA21(MEM_CH1_DQ24)
M_B_DQ25: U13.C2(DQU4) U22.AY23(MEM_CH1_DQ25)
M_B_DQ26: U13.D3(DQU6) U22.BA23(MEM_CH1_DQ26)
M_B_DQ27: U13.D7(DQU7) U22.BA17(MEM_CH1_DQ27)
M_B_DQ28: U13.A3(DQU0) U22.AY21(MEM_CH1_DQ28)
M_B_DQ29: U13.C8(DQU5) U22.AY17(MEM_CH1_DQ29)
M_B_DQ30: U13.B8(DQU1) U22.AY19(MEM_CH1_DQ30)
M_B_DQ31: U13.C7(DQU3) U22.BA19(MEM_CH1_DQ31)
M_B_DQ32: U22.AR8(MEM_CH1_DQ32) U25.F7(DQL1)
M_B_DQ33: U22.AN15(MEM_CH1_DQ33) U25.G2(DQL0)
M_B_DQ34: U22.AN17(MEM_CH1_DQ34) U25.H2(DQL4)
M_B_DQ35: U22.AU12(MEM_CH1_DQ35) U25.H7(DQL3)
M_B_DQ36: U22.AN12(MEM_CH1_DQ36) U25.J3(DQL6)
M_B_DQ37: U22.AN13(MEM_CH1_DQ37) U25.H3(DQL2)
M_B_DQ38: U22.AU13(MEM_CH1_DQ38) U25.H8(DQL5)
M_B_DQ39: U22.AU15(MEM_CH1_DQ39) U25.J7(DQL7)
M_B_DQ40: U22.AY3(MEM_CH1_DQ40) U25.A3(DQU0)
M_B_DQ41: U22.BD3(MEM_CH1_DQ41) U25.C8(DQU5)
M_B_DQ42: U22.BD1(MEM_CH1_DQ42) U25.B8(DQU1)
M_B_DQ43: U22.BC3(MEM_CH1_DQ43) U25.C7(DQU3)
M_B_DQ44: U22.AY1(MEM_CH1_DQ44) U25.C2(DQU4)
M_B_DQ45: U22.BA3(MEM_CH1_DQ45) U25.D3(DQU6)
M_B_DQ46: U22.BA2(MEM_CH1_DQ46) U25.C3(DQU2)
M_B_DQ47: U22.BE2(MEM_CH1_DQ47) U25.D7(DQU7)
M_B_DQ48: U9.J7(DQL7) U22.AR5(MEM_CH1_DQ48)
M_B_DQ49: U9.H2(DQL4) U22.BA8(MEM_CH1_DQ49)
M_B_DQ50: U9.H8(DQL5) U22.AU7(MEM_CH1_DQ50)
M_B_DQ51: U9.H7(DQL3) U22.AU5(MEM_CH1_DQ51)
M_B_DQ52: U9.J3(DQL6) U22.BA5(MEM_CH1_DQ52)
M_B_DQ53: U9.H3(DQL2) U22.BA7(MEM_CH1_DQ53)
M_B_DQ54: U9.F7(DQL1) U22.AU8(MEM_CH1_DQ54)
M_B_DQ55: U9.G2(DQL0) U22.BA10(MEM_CH1_DQ55)
M_B_DQ56: U9.C2(DQU4) U22.AP3(MEM_CH1_DQ56)
M_B_DQ57: U9.C8(DQU5) U22.AU2(MEM_CH1_DQ57)
M_B_DQ58: U9.D7(DQU7) U22.AV3(MEM_CH1_DQ58)
M_B_DQ59: U9.B8(DQU1) U22.AW3(MEM_CH1_DQ59)
M_B_DQ60: U9.D3(DQU6) U22.AN2(MEM_CH1_DQ60)
M_B_DQ61: U9.C3(DQU2) U22.AP1(MEM_CH1_DQ61)
M_B_DQ62: U9.A3(DQU0) U22.AR3(MEM_CH1_DQ62)
M_B_DQ63: U9.C7(DQU3) U22.AV1(MEM_CH1_DQ63)
M_B_DQSN0: U22.BK25(M\E\M\_\C\H\1\_\D\Q\S\0\) U30.A7(DQSU_C)
M_B_DQSN1: U22.BF25(M\E\M\_\C\H\1\_\D\Q\S\1\) U30.F3(DQSL_C)
M_B_DQSN2: U13.F3(DQSL_C) U22.BJ18(M\E\M\_\C\H\1\_\D\Q\S\2\)
M_B_DQSN3: U13.A7(DQSU_C) U22.AV21(M\E\M\_\C\H\1\_\D\Q\S\3\)
M_B_DQSN4: U22.AR15(M\E\M\_\C\H\1\_\D\Q\S\4\) U25.F3(DQSL_C)
M_B_DQSN5: U22.BC2(M\E\M\_\C\H\1\_\D\Q\S\5\) U25.A7(DQSU_C)
M_B_DQSN6: U9.F3(DQSL_C) U22.AW8(M\E\M\_\C\H\1\_\D\Q\S\6\)
M_B_DQSN7: U9.A7(DQSU_C) U22.AT3(M\E\M\_\C\H\1\_\D\Q\S\7\)
M_B_DQSP0: U22.BJ24(MEM_CH1_DQS0_P) U30.B7(DQSU_T)
M_B_DQSP1: U22.BD25(MEM_CH1_DQS1_P) U30.G3(DQSL_T)
M_B_DQSP2: U13.G3(DQSL_T) U22.BL18(MEM_CH1_DQS2_P)
M_B_DQSP3: U13.B7(DQSU_T) U22.AV19(MEM_CH1_DQS3_P)
M_B_DQSP4: U22.AR13(MEM_CH1_DQS4_P) U25.G3(DQSL_T)
M_B_DQSP5: U22.BB3(MEM_CH1_DQS5_P) U25.B7(DQSU_T)
M_B_DQSP6: U9.G3(DQSL_T) U22.AW7(MEM_CH1_DQS6_P)
M_B_DQSP7: U9.B7(DQSU_T) U22.AT1(MEM_CH1_DQS7_P)
M_B_DRAMRST#: C172.1 R178.1 U9.P1(RESET_N) U13.P1(RESET_N) U25.P1(RESET_N) U30.P1(RESET_N)
M_B_ODT0_MD: R177.1 R182.1 R222.2 U9.K3(ODT) U13.K3(ODT) U25.K3(ODT) U30.K3(ODT)
M_B_PARITY: R206.2 R624.1 U9.T3(PAR) U13.T3(PAR) U25.T3(PAR) U30.T3(PAR)
MA_DRAMRST#: R189.2 R196.2 U22.BC43(M\E\M\_\C\H\0\_\R\E\S\E\T\)
MAIND: PC60.1 PQ2.2(G) PQ10.2(G) PQ11.3(D) PQ19.2(G) PR77.2
MAINON: PQ12.2(BASE) PR6.2 PR83.1 PR98.1 PR184.2 PR188.2 PR249.2 R314.1 U14.30(PWM4/GPA4)
MAINON_ON_G: PQ1.2(G) PQ7.2(G) PQ8.2(G) PQ9.2(G) PQ11.2(G) PQ12.3(COLLECTOR) PQ24.2(G) PR78.2 PR82.1
MB_DRAMRST#: R178.2 R181.2 U22.BC15(M\E\M\_\C\H\1\_\R\E\S\E\T\)
MBCLK: PC234.1 PD2.1 PR105.2 PR262.2 R250.1 U14.110(SMCLK0/GPB3)
MBCLK_R: PJ16.4 PR262.1
MBDATA: PC235.1 PD3.1 PR106.2 PR263.2 R267.1 U14.111(SMDAT0/GPB4)
MBDATA_R: PJ16.3 PR263.1
MDI_0+: U3.1(MDIP0) U20.2(TD1+)
MDI_0-: U3.2(MDIN0) U20.3(TD1-)
MDI_1+: U3.4(MDIP1) U20.5(TD2+)
MDI_1-: U3.5(MDIN1) U20.6(TD2-)
MDI_2+: U3.6(MDIP2) U20.8(TD3+)
MDI_2-: U3.7(MDIN2) U20.9(TD3-)
MDI_3+: U3.9(MDIP3) U20.11(TD4+)
MDI_3-: U3.10(MDIN3) U20.12(TD4-)
MDSI_RCOMP: R507.1 U22.AL5(MDSI_RCOMP)
ME_WR#: Q33.2(G) R251.2
MEM_CH0_RCOMP: R175.1 U22.AY29(MEM_CH0_RCOMP)
MEM_CH1_RCOMP: R170.1 U22.AY27(MEM_CH1_RCOMP)
MIC2-VREFO: R335.1 R338.1 U16.29(MIC2-VREFO)
MX0: CN16.1 CP6.1(C1) RP1.9(R3) U14.58(KSI0/STB#)
MX1: CN16.2 CP6.3(C3) RP1.8(R5) U14.59(KSI1/AFD#)
MX2: CN16.3 CP6.5(C5) RP1.7(R7) U14.60(KSI2/INIT#)
MX3: CN16.4 CP6.7(C7) RP1.6(R9) U14.61(KSI3/SLIN#)
MX4: CN16.5 CP5.1(C1) RP1.4(R8) U14.62(KSI4)
MX5: CN16.6 CP5.3(C3) RP1.3(R6) U14.63(KSI5)
MX6: CN16.7 CP5.5(C5) RP1.2(R4) U14.64(KSI6)
MX7: CN16.8 CP5.7(C7) RP1.1(R2) U14.65(KSI7)
MY0: CN16.26 CP1.7(C7) U14.36(KSO0/PD0)
MY1: CN16.25 CP1.5(C5) U14.37(KSO1/PD1)
MY2: CN16.24 CP1.3(C3) U14.38(KSO2/PD2)
MY3: CN16.23 CP1.1(C1) U14.39(KSO3/PD3)
MY4: CN16.22 CP2.7(C7) U14.40(KSO4/PD4)
MY5: CN16.21 CP2.5(C5) U14.41(KSO5/PD5)
MY6: CN16.20 CP2.3(C3) U14.42(KSO6/PD6)
MY7: CN16.19 CP2.1(C1) U14.43(KSO7/PD7)
MY8: CN16.18 CP3.7(C7) U14.44(KSO8/ACK#)
MY9: CN16.17 CP3.5(C5) U14.45(KSO9/BUSY)
MY10: CN16.16 CP3.3(C3) U14.46(KSO10/PE)
MY11: CN16.15 CP3.1(C1) U14.51(KSO11/ERR#)
MY12: CN16.14 CP4.7(C7) U14.52(KSO12/SLCT)
MY13: CN16.13 CP4.5(C5) U14.53(KSO13)
MY14: CN16.12 CP4.3(C3) U14.54(KSO14)
MY15: CN16.11 CP4.1(C1) U14.55(KSO15)
MY16: C298.2 CN16.10 U14.56(KSO16/SMOSI/GPC3)
MY17: C299.2 CN16.9 U14.57(KSO17/SMISO/GPC5)
NBSWON#: C278.1 C443.2 R258.1 R325.2 R554.1 U14.107(PWRSW/GPE4)
NEW_CLK_24M_DEBUG: CN10.60(NFC_I2C_SM_CLK) R545.1
NEW_LAD0: CN10.58(NFC_I2C_SM_DATA) R522.2
NEW_LFRAME#_C: CN10.62(NFC_I2C_IRQ) R534.1
NGFF_SATA_DET#: CN15.10 Q26.2(G) R383.1
NUMLED#: R292.2 U14.80(DAC4/DCD0#/GPJ4)
ODD_POWER: TP38.1 U14.71(ADC5/DCD1#/GPI5)
PANEL_LED_EN: PR34.1 PR37.1 R498.1 U14.78(DAC2/TACH0B/GPJ2)
PCBEEP: C307.1 U16.12(PCBEEP)
PCBEEP_EC: D32.2(ANODE) U14.34(PWM7/RIG1#/GPA7)
PCH_ACPRESENT: TP63.1 U14.84(EGCLK/GPE3)
PCH_AZ_CODEC_RST_R#: D27.1(CATHODE) Q13.3(D)
PCH_BATLOW#: C85.2 R99.2 U22.J48(P\M\U\_\B\A\T\L\O\W\)
PCH_BKLTCTL: R86.1 R622.1 U22.B41(PNL0_BKLCTL)
PCH_BKLTEN: R115.1 R621.1 U22.C40(PNL0_BKLTEN)
PCH_BLON: R103.1 R621.2
PCH_BLON_EC: R107.1 U14.88(PS2DAT1/RTS0#/GPF3)
PCH_BLON_R: Q7.5(G) R101.1 R103.2 R107.2
PCH_BRIGHT: R451.2 R622.2
PCH_PCIERST#: R637.1 U22.H43(GPIO_139)
PCH_PLTRST#: R638.1 U22.D54(P\M\U\_\P\L\T\R\S\T\) U34.2(INA)
PCH_SPI_CLK: R394.1 U22.B29(FST_SPI_CLK)
PCH_SPI_CLK_EC: TP59.1 U14.105(FSCK/GPG7) U29.6(CLK)
PCH_SPI_CS0#: R37.1 TP1.1 U21.1(CE#) U22.C31(F\S\T\_\S\P\I\_\C\S\0\)
PCH_SPI_CS1#: TP50.1 U22.C32(F\S\T\_\S\P\I\_\C\S\1\)
PCH_SPI_IO2: R404.1 TP47.1 U22.A30(FST_SPI_IO2)
PCH_SPI_IO2_R: R404.2 R407.1 U21.3(IO2)
PCH_SPI_IO3: R401.2 TP48.1 U22.C29(FST_SPI_IO3)
PCH_SPI_IO3_R: R400.1 R401.1 U21.7(IO3)
PCH_SPI_SI: R391.1 TP45.1 U22.B31(FST_SPI_MOSI_IO0)
PCH_SPI_SI_EC: R546.1 TP60.1 U14.102(FMOSI/GPG4) U29.5(DI)
PCH_SPI_SI_R: R391.2 U21.5(SI)
PCH_SPI_SO: R410.1 TP49.1 U22.C30(FST_SPI_MISO_IO1)
PCH_SPI_SO_EC: R543.1 TP58.1 U14.103(FMISO/GPG5) U29.2(DO)
PCH_SPI_SO_R: R410.2 U21.2(SO)
PCH_SUS_STAT#: R127.2 U22.E52(S\U\S\_\S\T\A\T\)
PCH_SUSPWRDNACK: R463.2 U14.15(ECSMI#/GPD4) U22.F54(SUSPWRDNACK)
PCH_TPD_INT#: Q19.3(D) R111.2 R360.1 U22.AC48(GPIO_18)
PCH_VDDEN: R82.1 R620.1 U22.C41(PNL0_VDDEN)
PCIE_CLK_RCOMP: R97.1 U22.L10(PCIE_REF_CLK_RCOMP)
PCIE_CLKREQ0: R433.2 U22.C45(P\C\I\E\_\C\L\K\R\E\Q\1\)
PCIE_CLKREQ2_LAN#: R41.1 R420.2 U22.B45(P\C\I\E\_\C\L\K\R\E\Q\2\)
PCIE_CLKREQ3_WLAN#: Q38.3(D) R434.2 R623.2 U22.C44(P\C\I\E\_\C\L\K\R\E\Q\3\) U33.3(A1)
PCIE_LAN_WAKE#_R: Q1.1(EMITTER) R2.2 R4.1 R36.1 U3.21(LANWAKEB)
PCIE_RCOMPN: R453.2 U22.C5(P\C\I\E\2\_\U\S\B\3\_\S\A\T\A\3)
PCIE_RCOMPP: R453.1 U22.C6(PCIE2_USB3_SATA3_RCOMP_P)
PCIE_REQ_LAN#_R: R10.2 R41.2 U3.12(CLKREQB)
PCIE_RXN2_LAN: C14.2 U22.F6(PCIE_P2_RXN)
PCIE_RXN2_LAN_C: C14.1 U3.18(HSON)
PCIE_RXN3_WLAN: R591.2 U22.F9(PCIE_P3_USB3_P4_RXN)
PCIE_RXN3_WLAN_NGFF: CN10.43(PERN0) R591.1
PCIE_RXP2_LAN: C13.2 U22.E7(PCIE_P2_RXP)
PCIE_RXP2_LAN_C: C13.1 U3.17(HSOP)
PCIE_RXP3_WLAN: R590.2 U22.H9(PCIE_P3_USB3_P4_RXP)
PCIE_RXP3_WLAN_NGFF: CN10.41(PERP0) R590.1
PCIE_TXN2_LAN: C368.1 U3.14(HSIN)
PCIE_TXN2_LAN_C: C368.2 U22.B9(PCIE_P2_TXN)
PCIE_TXN3_WLAN: C366.2 R598.2
PCIE_TXN3_WLAN_C: C366.1 U22.A10(PCIE_P3_USB3_P4_TXN)
PCIE_TXN3_WLAN_NGFF: CN10.37(PETN0) R598.1
PCIE_TXP2_LAN: C369.1 U3.13(HSIP)
PCIE_TXP2_LAN_C: C369.2 U22.C9(PCIE_P2_TXP)
PCIE_TXP3_WLAN: C367.2 R597.2
PCIE_TXP3_WLAN_C: C367.1 U22.C10(PCIE_P3_USB3_P4_TXP)
PCIE_TXP3_WLAN_NGFF: CN10.35(PETP0) R597.1
PCIE_WAKE2_N: Q11.1(S) R169.2 U22.F45(P\C\I\E\_\W\A\K\E\2\)
PCIE_WAKE3_N: Q12.1(S) R281.2 U22.D50(P\C\I\E\_\W\A\K\E\3\)
PCIE_WAKE#_R: CN10.55(PEWAKE0#) Q37.1(S) R585.1 R592.2 R613.2
PCLK_TPM: C352.1 C416.1 R440.1 U28.19(LCLK/SCLK)
PD#: D26.2(ANODE) D27.2(ANODE) R346.1 R348.2 U16.47(PDB)
PERSTB: R22.2 R23.2 U3.19(PERSTB)
PHASE_VCGI: PC26.2 PL2.1 PQ14.1(S1) PQ14.2(S2) PQ14.3(S3) PQ16.5(D) PR12.1 PR140.1 PU10.10(PHASE)
PHASE_VNN: PC31.1 PL4.1 PQ15.5(D) PQ18.1(S1) PQ18.2(S2) PQ18.3(S3) PR10.2 PR137.1 PU1.10(PHASE)
PLTRST#: D6.1(CATHODE) R22.1 R460.1 R461.1 R560.1 R638.2 U14.22(LPCRST#/GPD2) U28.17(L\R\E\S\E\T\/S\P\I\_\R\S\T\/S\R) U34.4(OUT Y)
PLTRST#_2: CN10.52(PERST0#) R287.2 R560.2
PMON: PC100.2 PR42.1 PR110.2 PR113.1 PU1.19(PSYS)
PMU_RSTBTN#: C377.2 R194.1 R452.2 U22.C51(P\M\U\_\R\S\T\B\T\N\)
PMU_SLP_S0#: R201.1 R459.2 U22.C52(P\M\U\_\S\L\P\_\S\0\)
PMU_SUSCLK: TP7.1 U22.G49(PMU_SUSCLK)
PRE_SEL: R28.1 U6.27(PRE)
PROCHOT_EC: Q34.2(G) R295.2 U14.17(LPCPD#/GPE6)
PTP_PWR_EN#: R584.1 U14.125(SSCE1#/GPG0)
PWRLED#: R8.1 R9.1 U14.24(PWM0/GPA0)
R_SPK+: R381.2 U16.45(SPK-R+)
R_SPK+_CN: C329.1 CN17.1 R381.1
R_SPK-: R380.2 U16.44(SPK-R-)
R_SPK-_CN: C328.1 CN17.2 R380.1
RAM_ID0: R199.1 R200.2 U22.AE51(GPIO_20)
RAM_ID1: R171.2 R176.1 U22.AA51(GPIO_24)
RAM_ID2: R165.2 R166.1 U22.AA46(GPIO_25)
RAM_ID3: R186.1 R192.2 U22.AE41(GPIO_26)
RAM_ID4: R185.1 R191.2 U22.AE44(GPIO_29)
RAM_ID5: R164.1 R167.2 U22.AC41(GPIO_30)
REGN6V: PC87.1 PR127.1 PU2.24(REGN)
REGOUT: R406.2 U3.24(REGOUT)
RF_EN: C444.2 R559.1 U14.66(ADC0/GPI0)
RF_EN_C: CN10.56(W_DISABLE1#) R559.2
RF_KILL#_R: R523.1 U22.AC43(GPIO_33)
RING2: L2.1 R338.2 U16.17(MIC2-L/RING2)
RING2_R: C188.2 CN8.3(G/M) D7.1 L2.2
RREF: R233.2 U11.1(RREF)
RSET: R40.2 U3.31(RSET)
RSMRST#: R263.1 U14.112(RING#/PWRFAIL#/CK32KOUT/LPCRST#)
RTC_RST#: C301.1 J1.1 Q2.6(D) R358.2 U22.D27(R\T\C\_\R\S\T\)
RTC_TEST#: C300.1 Q2.3(D) R180.1 R357.2 U22.F25(R\T\C\_\T\E\S\T\)
RTC_X1: C361.2 R431.1 U22.D23(RTC_X1) Y2.1
RTC_X2: C362.2 R431.2 U22.F23(RTC_X2) Y2.2
S5_ON: PR44.2 PR100.2 PR173.2 PR174.1 R268.1 R275.1 R276.2 R312.1
S5_ON_R: R312.2 U14.69(ADC3/GPI3)
SATA_DEVSLP0: Q16.6(D) R343.1 R605.2
SATA_DEVSLP0_R: CN15.9 R605.1
SATA_DEVSLP1: Q15.6(D) R342.1 R604.2
SATA_GP0: TP6.1 U22.H37(GPIO_138)
SATA_RXN0: C458.2 U22.J5(SATA_P0_RXN)
SATA_RXN0_CN: C459.1 CN15.5
SATA_RXN0_HDD#_IC: C458.1 U32.4(B_OUTN)
SATA_RXN_1ST_HDD#_C_RD: C459.2 U32.12(B_INN)
SATA_RXP0: C460.2 U22.J7(SATA_P0_RXP)
SATA_RXP0_CN: C461.1 CN15.6
SATA_RXP0_HDD_IC: C460.1 U32.5(B_OUTP)
SATA_RXP_1ST_HDD_C_RD: C461.2 U32.11(B_INP)
SATA_TXN0: C455.2 U22.J2(SATA_P0_TXN)
SATA_TXN0_CN: C456.1 CN15.3
SATA_TXN0_HDD#_IC: C455.1 U32.2(A_INN)
SATA_TXN_1ST_HDD#_C_RD: C456.2 U32.14(A_OUTN)
SATA_TXP0: C451.2 U22.J3(SATA_P0_TXP)
SATA_TXP0_CN: C453.1 CN15.2
SATA_TXP0_HDD_IC: C451.1 U32.1(A_INP)
SATA_TXP_1ST_HDD_C_RD: C453.2 U32.15(A_OUTP)
SD_CD#: R552.1 U11.13(SP6)
SD_CD#_R: CN11.1(CD_SW) R552.2
SD_CLK: R593.1 U11.15(SP8)
SD_CLK_R: C467.1 CN11.7(CLK) R586.1 R593.2
SD_CMD: R571.1 U11.18(SP10)
SD_CMD_R: C452.1 CN11.4(CMD) R571.2
SD_D0: R608.1 U11.11(SP4)
SD_D1: R614.1 U11.10(SP3)
SD_D2: R553.1 U11.21(SP13)
SD_D3: R570.1 U11.20(SP12)
SD_D4: TP20.1 U11.19(SP11)
SD_D5: TP22.1 U11.16(SP9)
SD_D6: TP23.1 U11.14(SP7)
SD_D7: TP28.1 U11.12(SP5)
SD_DATA0_R: C481.1 CN11.9(DAT0) R608.2
SD_DATA1_R: C483.1 CN11.10(DAT1) R614.2
SD_DATA2_R: C438.1 CN11.2(DAT2) R553.2
SD_DATA3_R: C448.1 CN11.3(CD/DAT3) R570.2
SD_WP: R618.1 U11.8(SP1)
SD_WP_R: CN11.11(WP_SW) R618.2
SDREG: C225.2 U11.6(SDREG)
SENSEA: R340.1 R341.2 U16.13(HP/LINE1 JD)
SET1_VCGI: PR45.1 PR198.2 PU10.28(SET1)
SET1_VNN: PR57.2 PR212.1 PU1.28(SET1)
SET2_VCGI: PR48.1 PR199.2 PU10.27(SET2)
SET2_VNN: PR56.2 PR211.1 PU1.27(SET2)
SET3_VCGI: PR50.1 PR200.2 PU10.26(SET3)
SET3_VNN: PR55.2 PR210.1 PU1.26(SET3)
SIO_EXT_SCI#: R495.1 R496.2 R497.2 U14.23(ECSCI#/GPD3)
SIO_RCIN#: TP32.1 U14.4(KBRST#/GPB6)
SLEEVE: L5.1 R335.2 U16.18(MIC2-R/SLEEVE)
SLEEVE_R: C227.2 CN8.4(M/G) D15.1 L5.2
SMB1ALERT#: Q35.5(G) R405.1 R444.1 U22.A26(S\M\B\_\A\L\E\R\T\)
SMB_SOC_CLK: Q29.6(D) R398.1 R399.1 R403.1 U22.B27(SMB_CLK)
SMB_SOC_DAT: Q29.3(D) R397.1 R402.1 U22.C27(SMB_DATA)
SOC_OVRIDE: Q33.3(D) R483.2 U22.T55(MDSI_A_TE)
SOC_PCI_SERR#: R485.2 R486.2
SOC_PWRBTN#: C84.2 R446.2
SOC_RSMRST#: C119.2 R132.2 R249.2 R263.2 U22.F27(R\S\M\_\R\S\T\)
SOC_SERIRQ: R207.2 R216.1 R422.1 R524.1 R525.1 U10.4(B) U23.3(A)
SOC_SERIRQ_R: R422.2 U22.B37(LPC_SERIRQ)
SP14: TP19.1 U11.22(SP14)
SPI_CLK_A: R394.2 TP46.1 U21.6(SCLK)
SPI_CS0#_UR_ME: R538.2 TP57.1 U14.101(FSCE#/GPG3) U29.1(C\S\)
SPI_HOLD#: R541.2 U29.7(H\O\L\D\)
SPI_WP#: R547.2 U29.3(W\P\)
SPIVCC_ON: R259.1 R271.2 U14.100(SSCE0#/GPG2)
SPKR: D31.2(ANODE) U22.AA54(GPIO_35)
SUSB#: R236.2 R513.1 U22.D51(P\M\U\_\S\L\P\_\S\3\)
SUSB#_R: R236.1 U14.119(DSR0#/GPG6)
SUSC#: R296.1 R521.1 U22.J49(P\M\U\_\S\L\P\_\S\4\)
SUSLED#: R13.1 R14.1 U14.28(PWM2/GPA2)
SUSON: PR120.2 PR246.2 R550.1 U14.120(TMR0/GPC4)
SVID_ALERT#_R: R469.2 U22.G54(SVID0_ALERT_B)
SVID_CLK#_R: R462.1 U22.F55(SVID0_CLK)
SVID_DAT#_R: R471.1 U22.G53(SVID0_DATA)
SYS_HWPG: PR229.2 PR235.2 R300.1
SYS_SHDN#: PR130.1 PR226.1 PR232.2 PR233.2 R278.2
TEMP_MBAT#: PR91.2 PR258.1 PR261.2 U14.73(ADC7/CTS1#/GPI7)
THERMTRIP#: Q31.3(D) R225.2 R438.1 R439.1
THRMTRIP#_R: Q31.2(G) R439.2 R475.1 U22.J53(T\H\E\R\M\T\R\I\P\)
TOUCH_SCREEN_PWR: C42.2 C50.1 CN5.10 CN5.11 R69.2
TP_EN: CN12.8 R609.2
TP_INT#_R: C476.1 C477.2 Q17.1(S) Q18.2(G) R345.2 R352.1 R610.1
TP_INT#_R_C: CN12.7 R610.2
TPCLK: C479.2 CN12.2 R612.1 U14.89(PS2CLK2/GPF4)
TPD_EN: C475.2 R274.1 R609.1
TPD_INT#: Q17.3(D) R344.1 R345.1 U14.128(GPJ6)
TPDATA: C478.2 CN12.3 R611.1 U14.90(PS2DAT2/GPF5)
TPM_BADD: R205.2 U28.6(GPIO3/BADD)
TPM_SERIRQ: R524.2 U23.4(B) U28.27(SERIRQ)
TPM_VDD: C412.1 C417.1 C418.1 C421.1 C422.1 R184.2 R195.2 R528.2 U28.8(VDD1) U28.14(VHIO#1) U28.22(VHIO#2)
TS_EN: C375.2 R448.1 U14.32(PWM6/SSCK/GPA6)
TSEN_VCGI: PR157.1 PR160.1 PU10.16(TSEN)
TSEN_VNN: PR28.1 PR159.1 PU1.16(TSEN)
TX0_HDMI+: CN1.7(D0+) R18.2 U2.5(IN4) U2.6(NC4) U6.17(OUT_D0P)
TX0_HDMI-: CN1.9(D0-) R18.1 U2.4(IN3) U2.7(NC3) U6.16(OUT_D0N)
TX1_HDMI+: CN1.4(D1+) R17.2 U1.2(IN2) U1.9(NC2) U6.20(OUT_D1P)
TX1_HDMI-: CN1.6(D1-) R17.1 U1.1(IN1) U1.10(NC1) U6.19(OUT_D1N)
TX2_HDMI+: CN1.1(D2+) R16.2 U1.5(IN4) U1.6(NC4) U6.23(OUT_D2P)
TX2_HDMI-: CN1.3(D2-) R16.1 U1.4(IN3) U1.7(NC3) U6.22(OUT_D2N)
TXC_HDMI+: C17.2 CN1.10(CLK+) R19.2 U2.2(IN2) U2.9(NC2) U6.14(OUT_CLKP)
TXC_HDMI-: C17.1 CN1.12(CLK-) R19.1 U2.1(IN1) U2.10(NC1) U6.13(OUT_CLKN)
UGATE_VCGI: PR152.2 PU10.9(UGATE)
UGATE_VNN: PR19.1 PU1.9(UGATE)
USB2.0_CONN3N: L11.1 U22.R15(USB2_DN3)
USB2.0_CONN3P: L11.4 U22.R13(USB2_DP3)
USB3_1_RXN: R135.1 U22.H11(USB3_P1_RXN)
USB3_1_RXP: R148.1 U22.J11(USB3_P1_RXP)
USB3_1_TXN: C153.1 U22.A14(USB3_P1_TXN)
USB3_1_TXP: C154.1 U22.C14(USB3_P1_TXP)
USB30_RX0+_R: CN2.6(STDA_SSRX+) R31.2 U5.5(I/O-3)
USB30_RX0-_R: CN2.5(STDA_SSRX-) R30.2 U5.6(I/O-4)
USB30_RX0N: R30.1 U22.D15(USB3_P0_RXN)
USB30_RX0P: R31.1 U22.F15(USB3_P0_RXP)
USB30_TX0+_C: C26.2 R33.1
USB30_TX0+_R: CN2.9(STDA_SSTX+) R33.2 U5.4(I/O-2)
USB30_TX0-_C: C25.2 R32.1
USB30_TX0-_R: CN2.8(STDA_SSTX-) R32.2 U5.7(I/O-5)
USB30_TX0N: C25.1 U22.C15(USB3_P0_TXN)
USB30_TX0P: C26.1 U22.B15(USB3_P0_TXP)
USB31_RX1+_R: CN6.6(STDA_SSRX+) R148.2 U8.5(I/O-3)
USB31_RX1-_R: CN6.5(STDA_SSRX-) R135.2 U8.6(I/O-4)
USB31_TX1+_R: CN6.9(STDA_SSTX+) R160.2 U8.4(I/O-2)
USB31_TX1-_R: CN6.8(STDA_SSTX-) R154.2 U8.7(I/O-5)
USB31_TX1N_C: C153.2 R154.1
USB31_TX1P_C: C154.2 R160.1
USB_BT_N: CN10.5(USB_D-) R596.1
USB_BT_P: CN10.3(USB_D+) R595.1
USB_CAR7_N: R245.1 U22.U10(USB2_DN7)
USB_CAR7_P: R255.1 U22.U8(USB2_DP7)
USB_CAR_N_R: R245.2 U11.2(DM)
USB_CAR_P_R: R255.2 U11.3(DP)
USB_CCD6_N_R: CN5.34 D37.2 R466.2
USB_CCD6_P_R: CN5.33 D38.2 R467.2
USB_OC0#: R109.2 R110.1 U22.U54(U\S\B\2\_\O\C\0\)
USB_OC1#: R112.2 U4.3(OCB) U18.3(OCB) U22.U53(U\S\B\2\_\O\C\1\) U24.3(OCB)
USB_OTG_ID: R481.2 U22.V1(USB2_DUALROLE)
USB_TS5_N_R: CN5.37 R464.2
USB_TS5_P_R: CN5.36 R465.2
USB_VBUS_SNS: R484.2 R492.1 U22.V3(USB2_VBUS_SNS)
USBCOMP: R113.1 U22.U12(USB2_RCOMP)
USBON#: R260.1 U4.4(EN) U18.4(EN) U24.4(EN)
USBP0+_R: CN2.3(D+) R34.2 U5.10(I/O-6)
USBP0-_R: CN2.2(D-) R35.2 U5.1(I/O-1)
USBP0N: R35.1 U22.U5(USB2_DN0)
USBP0P: R34.1 U22.U7(USB2_DP0)
USBP1+_R: CN6.3(D+) R168.2 U8.10(I/O-6)
USBP1-_R: CN6.2(D-) R172.2 U8.1(I/O-1)
USBP1N: R172.1 U22.N3(USB2_DN1)
USBP1P: R168.1 U22.N2(USB2_DP1)
USBP3_C+: CN3.3(D+) ESD2.1 L11.3
USBP3_C-: CN3.2(D-) ESD2.6 L11.2
USBP4N: R596.2 U22.M3(USB2_DN4)
USBP4P: R595.2 U22.M1(USB2_DP4)
USBP6_CCDN: R466.1 U22.P3(USB2_DN6)
USBP6_CCDP: R467.1 U22.P1(USB2_DP6)
USBP_TOUCHN: R464.1 U22.R3(USB2_DN5)
USBP_TOUCHP: R465.1 U22.R2(USB2_DP5)
USBPWR1: C10.2 C11.2 C330.2 CN3.1(VBUS) ESD2.5(VDD) U4.1(OUT)
USBPWR2: C406.2 C407.2 C408.2 C411.2 CN6.1(VBUS) U8.2(VDD) U24.1(OUT)
USBPWR3: C7.2 C15.2 C331.2 C337.2 CN2.1(VBUS) U5.2(VDD) U18.1(OUT)
VA: PC1.1 PC2.1 PD1.1 PD4.1 PD4.2 PJ5.3 PJ5.4 PR128.1
VA1: PC22.1 PC140.1 PD4.3 PQ17.5(D) PR125.2
VA2: PC27.1 PQ17.1(S1) PQ17.2(S2) PQ17.3(S3) PR121.1 PR150.1 PR163.2
VCLK_VCGI: PR166.1 PU10.6(VCLK)
VCLK_VNN: PR29.1 PU1.6(VCLK)
VDIO_VCGI: PR179.1 PU10.4(VDIO)
VDIO_VNN: PR33.1 PU1.4(VDIO)
VL: PR80.1 PR131.1
VNN_ON: PR43.2 PR190.2 U14.76(TACH2/GPJ0)
VNN_PVCC1: PC28.2 PR158.2 PU1.12(PVCC)
VNN_SENSE: PR40.1 PR60.2 U22.AJ41(VNN_SENSE)
VNNSS_SENSE: PR39.1 PR61.2 U22.AJ43(VNN_VSS_SENSE)
VR_READY_VCGI: PR156.1 PU10.7(V\R\_\R\E\A\D\Y\)
VR_READY_VNN: PR25.1 PU1.7(V\R\_\R\E\A\D\Y\)
VR_SVID_ALERT#_VCORE: PR23.2 PR171.2 PR186.2 PR187.2 R468.2 R469.1
VREF_CA_DIMM0: C472.1 C474.1 JDIM1.164(VREFCA) R587.2 R588.2 R589.2 R603.1
VRON: PR32.2 U14.68(ADC2/GPI2)
VRON_VCGI: PC37.1 PR32.1 PR185.1 PR190.1 PU10.2(EN)
VRON_VNN: PC42.1 PR43.1 PR44.1 PU1.2(EN)
VRTC_3P3: C89.1 C92.1 R92.2 U22.P15(VCCRTC_3P3V)
VSTBY_FSPI: R232.2 R247.2 R256.1 R257.2 R542.2
WAKE_SRC_LAN: Q1.3(COLLECTOR) Q11.3(D) R4.2 R174.2
WAKE_SRC_WLAN: Q12.3(D) Q37.3(D) R284.2 R613.1
WLAN_LED#: CN10.6(LED#1) R572.2
WLAN_VDD: Q14.3(D) R322.1
WLANPWR#: Q14.2(G) R321.2 U14.35(RTS1#/GPE5)
WRST#: C236.1 D17.2(ANODE) Q23.6(D) R291.1 U14.14(WRST#)
XD_CD#: TP27.1 U11.7(XD_CD#)
XD_D7: TP18.1 U11.23(XD_D7)
XD_RE#: TP26.1 U11.9(SP2)
XDP_PRDY#: R511.1 U22.AH55(J\T\A\G\_\P\R\D\Y\)
XDP_PREQ#: R510.1 U22.AJ53(J\T\A\G\_\P\R\E\Q\)
XDP_TCK: R520.1 U22.AM53(JTAG_TCK)
XDP_TDI: R509.1 U22.AJ54(JTAG_TDI)
XDP_TDO: R515.1 U22.AL53(JTAG_TDO)
XDP_TMS: R514.1 U22.AL54(JTAG_TMS)
XDP_TRST#: R508.1 U22.AK53(J\T\A\G\_\T\R\S\T\)
XTAL1: C21.2 U3.28(CKXTAL1) Y1.1
XTAL2: C22.2 U3.29(CKXTAL2) Y1.3
XTAL192_IN: C394.2 R479.2 U22.U2(OSCIN) Y3.1
XTAL192_OUT: C390.2 R479.1 U22.T1(OSCOUT) Y3.3
N17893945: C24.1 TP3.1 U3.27(LED0)
N17893959: C23.1 TP2.1 U3.25(LED2)
N17893963: TP4.1 U3.26(LED1/GPO)
N17894030: C5.2 U20.1(TCT1) U20.4(TCT2) U20.7(TCT3) U20.10(TCT4)
N17899062: C284.2 U16.39(LDO2-CAP)
N17899068: C266.2 U16.35(CBN)
N17899074: C266.1 U16.37(CBP)
N17899116: C268.1 U16.34(CPVEE)
N17899118: C287.1 U16.19(MIC-CAP)
N17899208: TP42.1 U16.48(SPDIF-OUT)
N17899770: C311.1 U16.7(LDO3-CAP)
N17900044: R293.2 R294.2 U15.5(SET)
N17900328: D31.1(CATHODE) D32.1(CATHODE) R363.2
N18674815: Q30.2(G) R396.2 R437.1
N19419989: D41.1 R554.2 SW1.3 SW1.4
N19785488: Q18.3(D) Q19.2(G) R353.1
N19867916: R195.1 U28.4(PP)
N19868095: R539.2 U28.13(C\L\K\R\U\N\/GPIO04/S\I\N\T\)
N19868357: R184.1 U28.1(VSB)
N19868418: R526.1 U23.5(EO)
N20280006: PQ7.3(D) PR59.2
N20280012: PQ24.3(D) PR264.2
N22956619: PQ1.3(D) PR1.2
N24795992: R331.1 U16.20(VD33 STB)
N25027434: C468.1 Q36.2(G) R584.2
N25929013: Q3.3(D) R49.1 R64.1 R80.2
N25929051: C75.2 Q3.2(G) R89.2 R93.1
N25929294: TP43.1 U16.4(DC DET)
N26762117: D6.2(ANODE) R190.2 R197.2 U26.K5(RSTN)
N27652896: C324.1 Q23.2(G) Q23.3(D) R382.2
N27652903: R367.2 R368.2 R382.1
N30146783: Q31.5(G) Q31.6(D) R432.1
N30208544: Q28.2(BASE) R385.1 R386.2
N30244659: Q16.2(G) Q16.3(D) R351.1
N30245063: Q15.2(G) Q15.3(D) R350.1
N30246849: Q26.5(G) Q26.6(D) R371.1
N30273822: C410.2 R518.1
N30274264: R144.1 U9.E9(VSS#E9)
N30274422: R242.1 U13.E9(VSS#E9)
N30274704: R531.1 U25.E9(VSS#E9)
N30274864: R555.1 U30.E9(VSS#E9)
N30282349: C237.1 C258.1 JDIM1.255(VDDSPD) R301.1 R310.1
N30283102: C470.2 R594.2
N30283376: JDIM1.165(CS3#/C1) TP37.1
N30283378: JDIM1.162(CS2#/C0) TP41.1
N30318989: PC19.1 PC21.1 PC141.1 PC146.1 PJ3.2 PR146.2 PU6.8(V+#1) PU6.9(V+#2) PU6.22(V+#3) PU6.24(V+#4)
N30318999: PC124.1 PC125.1 PC126.1 PC127.1 PC128.1 PC136.1 PC137.1 PC138.1 PC139.2 PJ6.1 PL3.2 PR141.1
N30319333: PC118.1 PR132.2
N30319351: PC11.2 PR5.1
N30322034: PC81.1 PC90.1 PC91.1 PJ4.2 PL1.2 PR117.2
N30322038: PC88.1 PR95.2 PU3.4(VIN)
N30322042: PR116.1 PR117.1
N30322054: PC98.2 PR119.1 PU3.1(EN)
N30322056: PR118.2 PR119.2 PR120.1
N30322070: PR115.1 PR116.2 PU3.6(VFB)
N30322095: PR109.2 PU3.5(PG)
N30371514: C217.1 R256.2 U14.106(VSTBY_FSPI)
N30371961: R290.1 TP33.1
N30372639: R296.2 U14.18(RI1#/GPD0)
N30372887: R292.1 TP34.1
N30372945: C231.1 U14.12(VCORE)
N30377243: C233.2 R289.1
N30404052: PC161.1 PR170.2
N30404082: PC147.1 PC169.1 PJ7.1 PL5.2 PR144.1
N30404100: PC156.1 PC162.1 PJ8.1 PR167.1 PU7.9(VIN#1) PU7.10(VIN#2)
N30413525: PQ9.3(D) PR79.2
N30417403: PC85.1 PL10.2 PQ13.1(S1) PQ13.2(S2) PQ13.3(S3) PR94.1 PR257.1 PR259.1
N30417483: PC74.1 PR86.2
N30417534: PC95.2 PR104.1
N30417620: PR107.1 PR108.2 PU2.10(P\R\O\C\H\O\T\)
N30417647: PC85.2 PQ13.4(G) PR96.2
N30417687: PC22.2 PC27.2 PQ17.4(G) PR15.1
N30417707: PR122.1 PU2.5(ACOK)
N30417720: PR106.1 PU2.11(SDA)
N30417725: PR105.1 PU2.12(SCL)
N30417727: PR124.1 PU2.7(IADP)
N30417731: PR110.1 PU2.9(PMON)
N30417774: PR90.1 PR91.1 PU2.15(B\A\T\P\R\E\S\)
N30417841: PR112.1 PU2.8(IDCHG)
N30418865: PR92.2 PU2.20(SRP)
N30418874: PR93.2 PU2.19(SRN)
N30418916: PJ16.5 PR261.1
N30431765: PC93.1 PR99.1 PU4.4(VBIAS)
N30431769: PC108.1 PU4.12(CT1)
N30431771: PC107.1 PU4.10(CT2)
N30431804: PC92.1 PR98.2 PU4.5(ON2)
N30431812: PC94.1 PR100.1 PU4.3(ON1)
N30574961: EC2.2 LED1.4 R9.2
N30574965: EC3.2 LED1.3 R14.2
N30574981: EC4.2 LED2.4 R15.2
N30574985: EC1.2 LED2.3 R3.2
N30575269: C203.2 U11.24(V18)
N30954436: PC200.1 PR224.1 PR225.1 PU12.6(VO)
N30954444: PR223.1 PR224.2 PU12.7(ADJ)
N31161958: PC174.1 PR180.2 PU9.4(VBIAS)
N31161974: PC36.1 PU9.12(CT1)
N31161976: PC38.1 PU9.10(CT2)
N31162017: PC179.1 PR184.1 PU9.5(ON2)
N31162025: PC164.1 PR174.2 PU9.3(ON1)
N31255598: C312.1 D28.2 HE1.2(VCC) R370.1
N31257808: R377.2 U17.7(SDO/SA0)
N31411910: R271.1 R276.1 U12.3(EN)
N31539110: CN16.27 D24.1 R325.1
N31585508: CN7.11 R187.2
N31585541: CN7.15 R201.2
N31585543: CN7.13 R194.2
N31585594: CN7.2 R513.2
N31585612: CN7.5 R521.2
N31585632: CN7.9 R180.2
N31670929: Q24.3(D) SW2.3 SW2.4
N31709164: R6.2 R7.2 R10.1
N32197751: Q35.2(G) Q35.3(D) R583.1
N32197909: Q35.6(D) U31.1(F\O\N\)
N32459164: PC222.2 PR247.1
N32459172: PC226.1 PR253.2 PU15.4(VTTREF)
N32459174: PC62.1 PC64.1 PC214.1 PC216.1 PJ13.2 PQ21.5(D) PR243.1
N32459193: PC68.1 PC69.1 PC70.1 PC71.1 PC72.1 PC228.1 PC229.1 PJ14.2 PL9.2 PR252.1
N32459334: PR254.1 PU15.3(GND)
N32459384: PC66.1 PR85.2
N33096788: R617.1 U33.5(EO)
N33973281: PR133.1 PU5.1(SET)
N33973285: PC119.1 PR131.2 PU5.5(VCC)
N33973296: PR130.2 PU5.3(O\T\)
N33998046: PQ18.4(G) PR19.2
N33998081: PC33.1 PR168.2 PU1.13(VIN)
N33998093: PC44.1 PC191.2 PC195.1 PR54.1 PR60.1 PR219.2
N33998109: PC41.1 PR30.2
N33998124: PR47.2 PR51.1 PR134.1
N33998244: PR191.1 PU1.3(V\R\H\O\T\)
N33998269: PR10.1 PR41.1
N33998478: PR54.2 PU1.25(VSEN)
N33998484: PR57.1 PR65.2
N33998495: PR212.2 PR213.1
N33998499: PR56.1 PR67.2
N33998510: PR197.1 PR211.2
N33998512: PR55.1 PR66.2
N33998523: PR196.1 PR210.2
N33998541: PR31.2 PR36.1
N33998543: PR36.2 PU1.18(IMON)
N33999614: PR21.1 PR24.1 PR28.2 PR159.2
N33999624: PR16.1 PR21.2
N33999632: PR24.2 PR27.1
N34019717: PR63.2 PU10.25(VSEN)
N34019719: PC46.1 PC189.1 PC194.2 PR58.2 PR63.1 PR214.2
N34019737: PR198.1 PR201.1
N34019748: PR45.2 PR46.1
N34019771: PR199.1 PR207.2
N34019785: PR48.2 PR52.1
N34019789: PR200.1 PR208.2
N34019800: PR50.2 PR62.1
N34020717: PR172.2 PR176.1
N34020735: PR176.2 PU10.18(IMON)
N34020901: PR140.2 PR182.1
N34021029: PC155.1 PR14.2 PU10.13(VIN)
N34021054: PR177.1 PU10.19(PSYS)
N34021115: PC160.1 PR169.2
N34021177: PR136.1 PR183.2 PR194.1
N34021183: PR154.1 PR157.2 PR160.2 PR161.1
N34021195: PR154.2 PR155.1
N34021205: PR161.2 PR162.1
N34345368: R163.1 U26.A7(RFU#A7/NC)
N34396238: R269.1 U10.5(EO)
N34463015: PQ3.2(G) PQ4.3(COLLECTOR) PR17.2 PR20.1
N34463017: PQ3.3(D) PR22.2
N34463075: PQ4.2(BASE) PR35.1 PR37.2
N34466148: PR189.1 PU10.3(V\R\H\O\T\)
N34516046: R572.1 R573.1 TP61.1
N34640237: CN15.20 R604.1
N34664651: Q21.3(D) Q22.2(G) R336.1
N34725490: Q25.2(G) Q27.3(COLLECTOR) R372.2
N34728734: CN15.8 R606.1
N34749031: R182.2 U22.BC8(MEM_CH1_ODT0)
N34841935: CN5.4 R54.2
N34843450: CN5.13 R448.2
N34855062: R212.2 U22.AV29(MEM_CH0_VREFCA)
N34966351: PC57.2 PR74.2 PR75.1 PU13.12(FF)
N34966402: PC57.1 PR76.1
N34966644: PC217.2 PR236.2 PR237.1 PU14.9(FF)
N34966684: PC217.1 PR238.1
N34966797: PC65.1 PR80.2 PU14.12(LDO5)
N34967490: PR227.1 PR228.2 PR229.1 PR231.2
N34971076: PC51.1 PQ6.1(S) PR64.1 PR69.2
N34971086: C388.1 C389.1 L12.1 PQ6.3(D) PU8.8(IN) R474.2 R499.1
N34971104: PC51.2 PQ6.2(G) PR64.2 PR68.1
N34971124: PQ5.3(D) PR68.2
N34971155: PQ5.2(G) PR34.2
N35023087: R66.2 U6.36(REXT)
N35182776: R575.1 U32.10(REXT)
N35212197: TP10.1 U22.F19(XTAL_CLKREQ)
N35212200: TP5.1 U22.F17(C\N\V\_\R\F\_\R\E\S\E\T\)
N35276950: PQ8.3(D) PR70.2
N35413235: TP62.1 U22.F41(GPIO_146)
N35712957: C484.1 C485.2 CN15.18 CN15.19 R619.1
N35788414: PC184.1 PC187.1 PR178.2 PU12.3(VIN)
N35788542: PC196.1 PR222.1 PU12.4(VPP)
N35790435: PC186.1 PR188.1 PR195.1 PU12.2(VEN)
N35858654: PC20.1 PR12.2
N35858977: PQ14.4(G) PR152.1
N35935566: PC134.1 PR137.2
N36056010: PC170.1 PC171.1 PC172.1 PJ9.1 PL6.2 PR221.1
N36056030: PR216.1 PR217.2 PU11.6(VFB)
N36056032: PC193.1 PR205.2 PU11.4(VIN)
N36056052: PR217.1 PR221.2
N36056070: PC173.1 PR173.1 PU11.1(EN)
N36056085: PR215.1 PU11.5(PG)
N36138734: C119.1 R634.2
N36138851: C78.1 R633.2
N36374513: R636.2 R637.2 U34.1(INB)
N40446319: TP9.1 U22.R46(PMC_I2C_SCL)
N40446321: TP13.1 U22.R48(PMC_I2C_SDA)
N40523681: R497.1 U22.Y55(GPIO_37)
N40708508: C97.2 C98.2 C392.2 C393.2 D39.1(CATHODE) R95.1 R500.2
N41869277: C396.2 R494.1
N42791542: TP12.1 U22.P53(SIO_UART0_RXD)
N42791545: TP15.1 U22.M55(S\I\O\_\U\A\R\T\0\_\C\T\S\)
N42791548: TP8.1 U22.L53(S\I\O\_\U\A\R\T\2\_\C\T\S\)
N3442740345: TP52.1 U22.L2(USB2_DP2)
N3442740355: TP51.1 U22.L3(USB2_DN2)

Pads without a net: CN1 13 14; CN5 3; CN7 3 4 6 7 16 17 18; CN8 7; CN10 8 9 10 11 12 13 14 15 16 17 19 20 21 22 23 32 34 36 38 40 42 44 46 48 50 59 61 65 67; CN11 13 15; ESD2 3 4; NOREF#3 1; NOREF#4 1; NOREF#5 1; NOREF#7 1; NOREF#10 1; NOREF#11 1; PU1 14 15; PU6 7; PU10 14 15; PU12 5; U5 3 8; U6 2 4 9 10 12 25 26 37; U8 3 8; U9 T7; U12 4; U13 T7; U14 3; U16 14 15 16 23 24; U17 2 3; U22 A4 A7 A42 A46 A50 A53 A54 AA2 AA3 AA8 AA10 AA39 AA41 AA49 AA53 AC2 AC3 AC5 AC7 AC10 AC12 AC49 AC51 AD1 AD3 AE15 AE17 AE49 AG5 AG7 AG8 AG10 AG12 AG13 AG15 AG17 AG43 AG44 AH53 AJ5 AJ7 AJ10 AJ12 AJ15 AJ17 AJ49 AL2 AM3 AN5 AN7 AW44 B11 B13 B17 B19 B23 B25 B47 BC7 BF1 BF2 BF15 BG2 BG54 BH1 BH15 BH54 BH55 BJ13 BJ14 BJ42 BL2 BL3 BL12 BL44 BL53 BL54 C2 C3 C7 C11 C13 C17 C19 C25 C26 C38 C42 C46 C47 C48 C50 C54 D1 D2 D4 D11 D13 D17 D19 D29 D35 D47 E2 E5 F2 F11 F13 F29 F35 F37 F39 F47 G5 G7 G51 H1 H2 H4 H6 H27 H29 H31 H35 H41 H45 H47 H53 H55 J17 J25 J29 J31 J35 L21 L23 L25 L27 L29 L31 L39 L41 L43 L48 L49 L51 M23 M27 M29 M31 M43 N5 N7 N44 N48 N49 P23 P25 P27 P29 P31 P35 R10 R12 R41 R43 R44 R53 R54 U15 U39 U41 U43 U46 U48 U49 U51 V53 W12 W13 W54 Y1 Y3 Y53; U25 T7; U26 A1 A2 A6 A8 A9 A10 A11 A12 A13 A14 B1 B7 B8 B9 B10 B11 B12 B13 B14 C1 C3 C5 C7 C8 C9 C10 C11 C12 C13 C14 D1 D2 D3 D4 D12 D13 D14 E1 E2 E3 E5 E8 E9 E10 E12 E13 E14 F1 F2 F3 F10 F12 F13 F14 G1 G2 G3 G10 G12 G13 G14 H1 H2 H3 H12 H13 H14 J1 J2 J3 J5 J12 J13 J14 K1 K2 K3 K6 K7 K10 K12 K13 K14 L1 L2 L3 L12 L13 L14 M1 M2 M3 M7 M8 M9 M10 M11 M12 M13 M14 N1 N3 N6 N7 N8 N9 N10 N11 N12 N13 N14 P1 P2 P7 P8 P9 P10 P11 P12 P13 P14; U28 2 3 5 7 10 11 12 25 26 29 30 31; U30 T7

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 3897 vias
v2: diameter 0.61, hole 0.356, TOP to BOTTOM, 340 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.8V_LDO: length 10
  TOP w0.508: v1(45.37,45.03) 45.02,45.03 44.79,45.26 R232.1 ; v1(48.8,40.05) 49.3,40.05 C223.2 49.43,40.56 49.15,40.84 U12.5
  IN2 w0.508: v1(45.37,45.03) 45.84,45.03 48.8,42.07 v1(48.8,40.05)
3V_LDO: length 2.2
  TOP w0.127: R254.1 50.58,43.74 v1(51.09,43.23) 50.58,42.72 R266.1
5V_HSMBCK: length 2
  BOTTOM w0.127: D35.1 v1(122.21,90.85) R390.1
5V_HSMBDT: length 2
  BOTTOM w0.127: D36.1 v1(122.21,89.08) R395.1
+1.2V: length 70.3
  TOP w0.178: v1(115.73,84.5) 115.91,84.32 U6.30 ; U6.18 119.87,88.13 v1(120.05,88.31) ; v1(121.06,80.19) 121.07,80.19 U6.46 ; v1(121.57,88.31) 121.32,88.07 121.32,87.83 121.07,87.57 U6.15 ; v1(123.48,86.41) 123.48,86.28 123.12,85.92 U6.11 ; U6.43 v1(119.87,80.19) ; v1(123.48,83.82) 123.37,83.92 U6.6
  TOP w0.508: v1(158.66,51.1) 161.21,51.1 PR70.1 ; v1(122.97,80.35) 122.97,80.3 123.97,79.3 v1(128.33,79.3) 131.43,76.2 139.43,76.2 142.02,73.62 142.02,70.58 142.45,70.15 144.98,70.15 145.9,69.24 150.25,69.24 150.65,69.65 v1(153.02,69.65)
  IN1 w0.508: v1(153.02,69.65) 153.65,69.65 155.12,68.17 155.12,62.06 155.61,61.57 156.98,61.57 158.85,59.7 158.85,57.53 159.24,57.13 159.24,51.58 158.76,51.1 v1(158.66,51.1)
+1.2VSUS: length 152.7
  TOP w0.305: v1(132.59,54) 132.38,53.78 U9.B3 ; U9.A1 131.29,51.91 131.12,51.74 v1(130.99,51.74) ; U9.A9 v1(131.98,58.71) U9.B9 ; 135.17,34.52 U13.F2 135.58,34.97 v1(135.98,35.37) ; 135.17,34.52 v1(135.17,34.52) ; 135.17,34.52 134.78,34.91 U13.E2 ; U13.B9 v1(131.98,40.93) U13.A9 ; v1(137.62,40.93) 137.98,40.57 U13.J9 138.09,40.42 138.09,39.84 U13.J8 ; v1(132.67,36.18) 132.38,35.89 U13.B3 ; U9.F8 v1(135.98,57.11) U9.G7 ; U13.T9 144.32,40.53 v1(144.75,40.96) ; U9.L1 139.58,51.33 138.95,50.71 v1(138.83,50.71) ; v1(135.19,39.29) 135.19,39.34 U13.F8 U13.G7 ; U13.A1 131.53,34.09 v1(130.97,34.09) ; U9.G1 135.84,51.37 v1(135.78,51.37) ; U9.E7 134.78,56.72 v1(134.39,57.11) ; U13.E7 134.75,38.93 v1(134.39,39.29) ; U13.D9 134.03,40.58 v1(134.03,41.08) ; U9.F2 135.58,52.68 v1(135.18,52.28) 134.78,52.68 U9.E2 ; v1(137.66,51.21) 137.98,51.53 U9.J1 U9.J2 ; U13.G9 136.3,40.61 v1(136.3,41.09)
  TOP w0.381: 142.91,33.7 142.91,34 U13.R1 ; U9.D9 133.98,58.61 134.27,58.9
  TOP w0.508: R189.1 81.16,53.14 77.71,49.68 73.5,49.68 72.26,48.44 72.26,47.74 70.11,45.59 64.75,45.59 64.17,45.01 64.17,41.07 ; U9.R1 143.03,51.66 143.03,51.28 ; PQ2.3 143.03,68.38 138.72,64.06 135.92,64.06 135.54,63.68 v1(135.54,63.17) ; C157.1 148.5,58.6 149.79,59.89 151.77,59.89 152.05,60.18 v1(152.05,60.64) ; v1(152.81,50.24) 152.81,51.87 151.97,52.7 148.34,52.7 147.12,51.48
  IN1 w0.508: v1(135.54,63.17) 135.54,62.56 136.37,61.73 137.28,61.73 139.18,59.83 v1(139.18,59.47)
  BOTTOM w0.203: U13.J8 137.6,39.35 135.96,39.35 U13.F8
  BOTTOM w0.25: v1(87.37,30.27) 86.72,30.27 85.78,29.33 JDIM1.147 ; v1(88.84,29.56) 88.78,29.49 JDIM1.159 ; v1(87.39,29.56) 87.28,29.45 JDIM1.153 ; JDIM1.129 79.28,29.53 v1(79.33,29.59)
  BOTTOM w0.254: JDIM1.241 109.28,29.45 v1(109.39,29.56) ; JDIM1.54 60.53,17.97 v1(59.93,17.38) ; v1(74.81,29.59) 74.78,29.55 JDIM1.111 ; JDIM1.33 55.27,29.39 v1(54.88,29.78) ; JDIM1.220 v1(104.03,18.72) ; v1(81.26,18.74) 81.02,18.98 JDIM1.136 ; v1(66.12,26.9) 65.78,27.24 JDIM1.75 ; v1(71.29,21.43) 71.03,21.17 JDIM1.96 ; JDIM1.142 v1(82.53,21.69) ; v1(88.84,29.56) 89.57,29.56 89.78,29.36 JDIM1.163 ; v1(77.78,29.57) JDIM1.123 ; U9.A9 v1(131.98,58.71) ; U30.C1 U13.D9 ; v1(93.53,21.39) JDIM1.178 ; v1(76.03,29.72) 76.28,29.47 JDIM1.117 ; v1(75.02,21.39) JDIM1.112 ; v1(82.28,29.56) JDIM1.141 ; v1(78.02,21.47) JDIM1.124 ; JDIM1.154 v1(87.53,21.39) ; v1(98.66,29.79) 98.78,29.68 JDIM1.199 ; JDIM1.160 v1(89.02,21.39) ; JDIM1.12 50.03,18.99 50.28,18.74 v1(50.59,18.74) ; v1(79.53,21.35) JDIM1.130 ; v1(134.02,51.28) 134.02,51.52 133.98,51.56 U9.D1 ; v1(76.53,21.47) JDIM1.118 ; v1(80.78,29.8) JDIM1.135 ; JDIM1.148 v1(86.02,21.39)
  BOTTOM w0.305: U13.F8 135.41,39.56 135.41,39.52 v1(135.19,39.29) 135.19,39.32 U30.E2 134.39,39.34 v1(134.39,39.29) ; U25.E2 134.39,57.12 v1(134.39,57.11) ; U30.B3 132.4,38.93 v1(132.82,38.51) ; v1(131.93,51.51) 132.33,51.91 U25.B9 ; v1(134.03,41.08) 134.03,40.58 U13.D9 ; U9.G1 136.32,51.91 v1(135.78,51.37) ; U25.E7 134.73,53.51 v1(134.37,53.87) 134.44,53.94 135.95,53.94 U25.G7 ; v1(135.17,34.52) 135.17,34.52 U13.F2 ; v1(135.18,52.28) 135.58,52.68 U9.F2 ; U13.A1 131.53,34.09 v1(130.97,34.09) ; v1(138.83,50.71) 138.95,50.71 139.35,51.1 139.35,51.68 U9.L1 ; U9.J2 U9.J1 137.98,51.53 137.68,51.23 137.68,51.23 v1(137.66,51.21) ; U30.E7 134.72,35.73 v1(134.27,36.18) ; v1(135.98,57.11) U9.F8 ; v1(134.22,33.65) 134.22,33.89 U13.D1 ; U13.A9 v1(131.98,40.93) ; v1(130.99,51.74) 131.41,51.74 U9.A1 ; U25.T9 143.52,51.85 143.52,51.41 v1(144.06,50.87) ; U25.B3 132.38,56.57 v1(132.68,56.27) ; U30.G7 136.34,35.73 v1(135.98,35.37) ; U30.B9 132.34,34.09 132.34,33.68 131.91,33.25 v1(131.55,33.25)
  BOTTOM w0.508: R536.2 152.05,49.85 152.44,50.24 v1(152.81,50.24) 152.31,50.75 152.31,52.14 152.11,52.37 151.88,52.37 151.87,52.36 R181.1 ; R589.1 v1(91.73,18.72) ; R512.1 v1(152.05,60.64)
  vias: v1(55.07,19.51) v1(56.7,39.47) v1(108.62,31.29) v1(108.62,30.66) v1(108.95,30.07) v1(109.25,30.66) v1(109.89,30.4) v1(110.27,29.77) v1(110.52,30.4) v1(111.03,29.77) v1(111.28,30.4) v1(133.18,32.94) v1(134.02,50.61) v1(134.38,59.51) v1(136.63,33.56) v1(136.61,32.87) v1(136.81,58.9) v1(137.58,59.47) v1(138.38,34.53) v1(139.18,58.71) v1(139.21,41.6) v1(139.18,33.73) v1(140.16,19.1) v1(140.19,18.46) v1(140.19,17.83) v1(140.88,19.1) v1(140.88,18.46) v1(140.88,17.83) v1(141.51,19.1) v1(141.51,18.46) v1(141.51,17.83) v1(142.15,19.1) v1(142.15,18.46) v1(142.15,17.83) v1(142.23,50.7) v1(142.27,33.45) v1(143.18,59.51) v1(144.64,33.26) v1(144.78,58.71) v2(147.61,23.67)
+1.05V: length 87.4
  TOP w0.508: v1(81.15,72.06) 80.52,72.06 80.02,72.57 80.02,74.22 78.99,75.25 78.99,75.47 78.4,76.06 78.31,76.19 78.31,76.38 v1(77.73,76.96) ; PR18.1 50.33,69.78 49.55,69 PC32.1 ; PR23.1 49.16,69.15 PC32.1 ; v1(51.11,66.96) 50.58,67.49 PR26.1 50.21,67.73 49.55,68.38 PC32.1
  IN2 w0.508: v1(51.11,66.96) 51.11,66.65 48.8,64.34 44.48,64.34 43.77,63.63 42.04,63.63 ; v1(41.41,64.84) 41.41,64.26 42.04,63.63 ; 72.63,49.02 72.63,46.3 71.76,45.44 62.08,45.44 55.4,52.12 55.4,56.49 54.39,57.5 49.89,57.5 47.91,59.49 43.84,59.49 43.58,59.23 42.83,59.23 42.39,59.68 42.39,60.74 42.98,61.34 42.98,62.05 42.04,63 42.04,63.63
  IN3 w0.508: v1(83,65.91) 82.99,65.92 82.99,66.42 82.61,66.8 82.25,66.8 81.24,67.82 81.24,71.98 v1(81.15,72.06)
  BOTTOM w0.254: R468.1 R470.1 80.77,71.68 v1(81.15,72.06)
  BOTTOM w0.508: R457.1 79.41,75.28 v1(77.73,76.96) ; PR187.1 41.05,65.2 v1(41.41,64.84) ; PR187.1 PR192.1 ; PR187.1 PR181.1 PC165.1
  vias: v1(79.22,55.4) v1(79.28,56.03) v1(79.74,56.49) v1(79.92,55.88) v1(80.17,56.95) v1(80.37,56.34) v1(80.68,57.33) v1(81.15,57.76) v1(81.69,60.12) v1(122.62,78.66) v1(122.62,78.03) v1(123.25,78.66) v1(123.25,78.03) v1(123.89,78.66) v1(123.89,78.03)
+1.5V: length 52.7
  TOP w0.508: R366.2 181.41,9.96 181.52,9.85 181.62,9.85 181.77,9.7 v1(181.77,9.45) ; L9.1 172.15,19.99 C283.2 169.2,22.16 v1(168.59,22.78) 167.29,22.78 v1(165.89,24.18) Q13.2
  IN2 w0.508: v1(181.77,9.45) 178.34,9.45 177.58,10.21 175.42,10.21 172.63,7.42 166.78,7.42 166.4,7.03 v1(166.4,6.53)
  IN3 w0.508: v1(165.89,24.18) 165.89,22.91 167.08,21.73 167.08,20.33 166.66,19.91 166.66,17.57 166.28,17.19 164.88,17.19 161.83,14.15 161.83,10.21 164.67,7.36 165.95,7.36 166.4,6.92 v1(166.4,6.53)
  vias: v1(161.35,48.39) v1(161.35,47.75)
