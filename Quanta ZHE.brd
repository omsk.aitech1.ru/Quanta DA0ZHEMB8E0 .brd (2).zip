# Allegro board Quanta ZHE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQSP2: length 43.8
  TOP w0.127: v1(135.98,36.13) 135.98,35.98 136.23,35.73 U13.G3
  IN3 w0.178: v1(113.25,42.49) 113.03,42.26 113.03,42.04 118.13,36.93 134.58,36.93 134.93,36.58 135.36,36.58 135.81,36.13 v1(135.98,36.13)
  BOTTOM w0.089: U22.BL18 102.19,52.24 102.19,51.64 102.53,51.3 102.53,49.17 103.22,48.48 103.31,48.48 103.33,48.46
  BOTTOM w0.203: v1(113.25,42.49) 113.19,42.49 113,42.68 113,43.04 111.99,44.04 107.43,44.04 105.34,46.14 105.34,46.45 103.33,48.46
M_B_DQSP3: length 48.5
  TOP w0.203: v1(123.04,37.62) 122.82,37.84 122.82,38.05 123.45,38.68 128.86,38.68 129.63,37.91 131.66,37.91 132.13,38.38 132.13,38.68 U13.B7
  IN1 w0.089: v1(102.09,58.67) 101.44,58.03 101.44,56.92 101.89,56.47 101.89,54.7 102.04,54.56 102.04,53.49 102.28,53.25 102.28,50.93 102.66,50.56 102.71,50.56
  IN1 w0.152: 102.71,50.56 103.61,49.65 103.61,46.38 108.12,41.87 110.98,41.87 111.65,41.2 112.8,41.2 115.62,38.38 122.46,38.38 122.76,38.07 122.76,37.89 v1(123.04,37.62)
  BOTTOM w0.089: U22.AV19 v1(102.09,58.67)
M_B_DQSP4: length 46.7
  IN3 w0.089: 111.28,55 111.23,54.95 110.08,54.95 109.25,55.77 109.25,56.87 108.82,57.3 108.82,58.52 108.42,58.91 104.48,58.91 104.41,58.98 104.41,59.07 v1(104.68,59.34)
  IN3 w0.178: 111.28,55 113.28,55 115.78,52.5 116.26,52.5 117.08,51.68 117.08,51.23 120.79,47.52 124.29,47.52 125.64,46.18 127.3,46.18 128.51,47.38 128.51,51.33 133.62,56.44 135.9,56.44 v1(135.98,56.36)
  BOTTOM w0.089: v1(104.68,59.34) U22.AR13
  BOTTOM w0.14: U25.G3 136.33,56.71 v1(135.98,56.36)
M_B_DQSP5: length 29.9
  BOTTOM w0.089: U22.BB3 109.39,56.25 109.49,56.18 109.52,56.17 110.19,56.17 110.62,55.74 112.79,55.74 112.86,55.8 112.88,55.8
  BOTTOM w0.102: U25.B7 132.24,53.65 132.24,53.81 131.76,54.28 131.25,54.28 131.2,54.33 131.17,54.33
  BOTTOM w0.203: 131.17,54.33 130.93,54.33 128.86,56.4 128.86,58.01 127.45,59.43 120.82,59.43 120.25,59.99 119,59.99 117.38,58.37 117.38,57.69 117.26,57.57 v1(116.58,57.57) 116.58,56.97 116.43,56.82 116.06,56.82 115.04,55.8 112.88,55.8
M_B_DQSP6: length 36
  TOP w0.127: v1(135.03,55.13) 135.02,55.13 134.73,54.85 134.73,54.43 135.05,54.11 135.78,54.11 136.06,53.83 U9.G3
  IN1 w0.089: v1(107.53,57.43) 107.4,57.31 107.4,57.19 107.53,57.06 109.06,57.06 110.32,55.8 110.91,55.8 111.18,56.08 112.01,56.08 112.05,56.12
  IN1 w0.152: v1(135.03,55.13) 134.92,55.13 134.78,55.27 134.78,55.64 134.31,56.11 133.84,56.11 132.99,56.96 129.16,56.96 126.05,60.07 118.6,60.07 114.65,56.12 112.05,56.12
  BOTTOM w0.089: v1(107.53,57.43) U22.AW7
M_B_DQSP7: length 32.5
  TOP w0.203: v1(128.38,62.69) 128.58,62.89 128.76,62.89 129.02,62.63 129.02,57.04 130.21,55.85 131.76,55.85 132.06,56.16 132.06,56.59 132.18,56.71 U9.B7
  IN3 w0.178: v1(128.38,62.69) 128.12,62.94 128,62.94 127.84,62.79 127.84,62.16 126.72,61.03 115.03,61.03 114.48,60.48 114.48,60.1 114.61,59.97 v1(114.66,59.97)
  BOTTOM w0.089: v1(114.66,59.97) 114.54,59.97 114.43,59.87 114.43,59.54 114.19,59.29 109.68,59.29 109.59,59.21 U22.AT1
M_B_DRAMRST#: length 62.4
  TOP w0.127: 146.89,52.37 142.44,52.37 U9.P1 ; U13.P1 142.44,34.59 146.36,34.59 148.06,36.29 148.32,36.29 149.08,37.05 v1(149.08,37.58)
  TOP w0.14: 146.89,52.37 147.01,52.37 148.79,54.15 149.33,54.15 149.7,54.51 149.7,55.09 149.38,55.4 v1(149.14,55.4)
  IN3 w0.127: v1(149.14,55.4) 149.14,55.42 152.46,52.1 152.46,51.86 152.46,51.22 153.26,50.42 153.26,48.32 152.81,47.88 152.64,47.88 152.04,47.28 152.04,46.33 152.4,45.97 152.4,45.1 152.39,45.1 152.39,39.77 150.21,37.58 v1(149.08,37.58)
  BOTTOM w0.102: 149.26,55.28 v1(149.14,55.4)
  BOTTOM w0.127: v1(149.08,37.58) 149.08,37.8 148.09,38.78 146.72,38.78 145.37,40.13 142.65,40.13 142.25,40.53 U30.P1 ; U25.P1 142.25,58.31 142.65,57.91 146.44,57.91 148.95,55.4 v1(149.14,55.4)
  BOTTOM w0.14: 149.26,55.28 149.38,55.28 149.7,54.97 149.7,54.21 149.27,53.78 C172.1 149,53.77 149.64,53.14 149.64,52.76 R178.1
M_B_ODT0_MD: length 73.7
  TOP w0.127: U9.K3 138.92,53.65 138.92,53.8 138.13,54.58 137.7,54.58 137.6,54.68 v1(137.6,54.93) ; v1(137.6,37.14) 137.6,36.88 137.73,36.75 137.88,36.75 138.41,36.22 138.72,36.22 138.92,36.02 138.92,35.87 U13.K3
  TOP w0.203: v1(116.25,51.44) 114.47,49.66 114.05,49.66 113.8,49.91 113.8,50.37 115.78,52.35 115.78,54.36 R182.1 R177.1 ; R222.2 140.12,47.93 v1(139.2,47.93)
  IN3 w0.178: v1(137.6,37.14) 137.6,37.55 138.46,38.41 138.46,38.99 139.05,39.57 139.05,40.16 139.66,40.77 139.66,44.04 140.03,44.41 140.03,45.32 139.76,45.59 139.76,47.37 v1(139.2,47.93) 139.2,46.36 139.05,46.2 138.84,46.2 138.67,46.38 138.67,49.48 139.61,50.42 139.61,51.66 138.34,52.93 138.34,54.13 137.6,54.87 v1(137.6,54.93)
  BOTTOM w0.127: U30.K3 138.78,38.67 137.6,37.49 v1(137.6,37.14) ; U25.K3 138.78,56.59 137.6,55.42 v1(137.6,54.93)
  BOTTOM w0.203: v1(139.2,47.93) 139.57,48.29 139.57,48.91 139.05,49.43 135.95,49.43 135.11,48.59 130.29,48.59 127.46,45.76 125.48,45.76 124.05,47.19 120.62,47.19 116.37,51.44 v1(116.25,51.44)
M_B_PARITY: length 37.5
  TOP w0.127: v1(146.45,55.42) 146.45,54.57 145.39,53.51 U9.T3 ; v1(149.66,50.49) 150.02,50.85 R624.1 ; v1(146.26,37.58) 146.18,37.5 146.18,36.17 145.75,35.73 U13.T3
  TOP w0.14: R206.2 v1(149.66,50.49)
  IN3 w0.14: v1(146.45,55.42) 146.45,55.42 146.45,54.6 148.57,52.47 148.89,52.47 149.79,51.58 149.79,50.62 v1(149.66,50.49) 149.66,48.39 149.08,47.8 149.08,43.79 149.3,43.57 149.3,41.55 148.67,40.92 148.67,40.36 146.26,37.95 v1(146.26,37.58)
  BOTTOM w0.127: v1(146.26,37.58) 144.92,38.93 U30.T3 ; v1(146.45,55.42) 145.17,56.71 U25.T3
MA_DRAMRST#: length 10.6
  TOP w0.14: R196.2 R189.2 84.72,52.65 v1(87.92,52.65) 89.34,52.65 90.13,53.44 90.13,55.29 v1(90.69,55.85)
  BOTTOM w0.089: v1(90.69,55.85) 90.76,55.85 U22.BC43
MAIND: length 289.3
  TOP w0.127: 144.05,71.17 v1(143.03,72.19) 142.78,72.44 v1(142.78,73.96) ; v1(158.66,32.66) PQ11.3 158.66,34.16 159.35,34.86 PC60.1 159.52,35.26 PR77.2 ; PQ10.2 120.3,30.91 v1(120.3,28.88)
  IN1 w0.089: v1(20.89,59.36) 21.24,59 21.24,57.52 19.27,55.55 19.27,47.85 23.76,43.36 24.97,43.36 26.26,42.07 26.26,41.02 27.9,39.37 28.34,39.37 28.82,38.9 28.82,36.72 31.86,33.68 31.99,33.68 32.15,33.52 32.21,33.46 32.31,33.36 33.81,31.86 33.81,29.11 35.31,27.61 41.61,27.61 42.9,26.32 42.9,21.23 48.98,15.14 57.97,15.14 60.66,12.45 75.45,12.45 76.09,13.09 85.92,13.09 90.37,17.53 98.18,17.53 98.77,18.13 111.3,18.13 113.75,20.58 115.84,20.58 118.22,22.96 124.64,22.96 125.97,24.29 125.97,27.28 123.96,29.28 120.7,29.28 v1(120.3,28.88)
  IN3 w0.127: v1(142.78,73.96) 143.28,73.47 153.31,73.47 153.95,74.12 164.52,74.12 166.36,72.27 166.36,69.88 164.69,68.21 163.88,68.21 163.61,67.94 162.6,66.94 162.6,60.08 163.54,59.14 163.54,55.34 164.35,54.53 165.03,54.53 165.48,54.08 165.48,51.26 163.4,49.18 163.4,49.18 161.13,46.91 161.13,38.16 158.97,36 158.97,32.98 v1(158.66,32.66) 158.31,33.01 154.9,33.01 152.87,35.04 151.17,35.04 148.53,32.39 144.25,32.39 144.07,32.22 142.19,32.22 139.92,29.95 139.92,29.07 139.66,28.81 124.94,28.81 123.95,29.81 121.23,29.81 120.31,28.88 v1(120.3,28.88)
  BOTTOM w0.127: PQ19.2 24.42,60.88 22.77,60.88 22.38,60.5 22.38,59.74 22,59.36 v1(20.89,59.36)
MAINON: length 254.8
  TOP w0.127: v1(148.99,29.77) PR83.1 154.75,31.18 PQ12.2 ; v1(30,28.47) 29.46,27.93 25.34,27.93 24.19,26.78 U14.30 21.31,26.78 R314.1 ; PR6.2 149,77.89 149,76.25 149.51,75.74 v1(149.88,75.74) 154.39,71.24 v1(154.39,69.85) ; PR98.1 v1(154.59,14.4)
  IN1 w0.089: v1(154.59,14.4) 151.46,14.4 150.15,15.7 150.15,16.64 149.96,16.84 149.96,17.76 149.85,17.88 149.85,24.72 148.11,26.46 148.11,28.89 v1(148.99,29.77) 150.89,31.66 157.94,31.66 158.32,31.27 158.94,31.27 159.25,31.58 159.25,39.1 157.49,40.85 157.49,43.75 158.73,44.98 158.73,45.1 160.33,46.7 160.33,48.73 160.82,49.22 160.82,50.02 161.15,50.35 161.15,59.2 160.82,59.53 160.82,62.41 v1(159.77,63.46) 158.99,64.25 158.99,65.25 v1(158.4,65.84) 156.24,63.68 155.86,63.68 155.68,63.86 155.68,68.56 v1(154.39,69.85) ; v1(137.45,23.93) 136.75,24.62 136.75,26.44 136.39,26.8 129.28,26.8 124.88,22.39 118.49,22.39 116.1,19.99 113.97,19.99 111.53,17.56 99.01,17.56 98.41,16.96 90.6,16.96 86.16,12.51 76.32,12.51 74.6,10.79 60.91,10.79 58.53,13.16 49.33,13.16 47.79,14.7 46.88,14.7 38.11,14.7 34.83,17.98 34.83,19.6 33.77,20.66 33.77,26.95 33.44,27.28 31.71,27.28 30.79,28.2 30.35,28.2 30.08,28.47 v1(30,28.47)
  IN3 w0.127: v1(148.99,29.77) 147.84,29.77 147.52,29.44 144.44,29.44 141.52,26.53 141.52,25.34 139.66,23.48 137.89,23.48 v1(137.45,23.93)
  BOTTOM w0.127: PR249.2 v1(137.45,23.93) ; PR188.2 160.42,64.5 159.99,64.07 159.99,63.68 v1(159.77,63.46) ; v1(158.4,65.84) 158.03,65.84 PR184.2
MAINON_ON_G: length 243.3
  TOP w0.127: 158.19,54.16 PQ8.2 157.13,55.22 v1(157.13,55.68) 157.13,55.93 PQ7.2 ; 158.19,54.16 158.78,53.57 158.78,51.87 158.66,51.74 158.4,51.74 158.07,51.41 158.07,50.8 158.4,50.47 159.59,50.47 v1(160.22,49.83) ; 158.19,54.16 164.1,54.16 164.22,54.28 165.01,54.28 165.7,53.58 168.2,53.58 v1(169.91,55.29) ; PQ9.2 117,35.62 120.94,31.69 v1(120.94,28.88) ; PQ1.2 108.95,83.16 108.24,83.87 v1(108.24,84.12) ; v1(158.66,32.03) 158.66,29.99 PR82.1 157.64,30.82 PQ11.2 157.64,32.79 157.13,33.3 PQ12.3 155.18,33.3 153.7,34.77 PR78.2
  IN1 w0.089: v1(137.32,9.47) 137.32,8.34 138.61,7.05 146.93,7.05 149.9,10.03 151.44,10.03 152.31,10.89 152.31,13.28 149.96,15.63 149.96,16.57 149.49,17.04 149.41,17.04 149.06,17.39 149.06,20.37 149.66,20.97 149.66,24.64 147.63,26.68 147.63,28.98 150.5,31.85 158.48,31.85 v1(158.66,32.03) 159.06,32.43 159.06,39.02 157.3,40.78 157.3,43.82 158.54,45.06 158.54,45.18 160.14,46.78 160.14,48.81 160.22,48.9 v1(160.22,49.83) ; v1(169.91,55.29) 169.05,56.16 169.05,64.95 169.04,64.96 169.04,65.93 168.94,66.03 168.94,66.08 167.51,67.52 167.51,71.83 167.51,71.83 167.51,72.69 165.89,74.31 162.53,74.31 162.05,74.79 159.4,74.79 158.81,75.39 157.16,75.39 153.28,79.26 150.76,79.26 147.87,82.15 144.24,82.15 143.15,83.24 127.43,83.24 126.28,84.4 123.12,84.4 122.82,84.69 116.61,84.69 116.34,84.96 108.82,84.96 108.24,84.38 v1(108.24,84.12)
  IN3 w0.127: v1(158.66,32.03) 157.93,32.75 154.8,32.75 153.4,34.15 150.65,34.15 148.63,32.14 144.35,32.14 144.18,31.96 142.29,31.96 140.18,29.85 140.18,28.97 139.77,28.56 124.83,28.56 123.84,29.55 121.61,29.55 v1(120.94,28.88)
  BOTTOM w0.127: 137.19,8.43 137.19,9.34 v1(137.32,9.47)
MB_DRAMRST#: length 64.7
  TOP w0.14: v1(112.18,50.49) 112.18,52.78 v1(112.16,52.8)
  IN1 w0.089: v1(112.16,52.8) 112.19,52.77 116.01,52.77 120.7,57.46 124.96,57.46 129.83,52.59 129.83,52.33 131.98,50.18 137.5,50.18 138.21,50.9 138.21,51.41 139.05,52.25 146.44,52.25 148.59,50.09 150.41,50.09 150.78,50.47 150.78,51.33 v1(151.01,51.56)
  IN3 w0.127: v1(112.18,50.49) 112.18,50.71 111.7,51.19 109.25,51.19 109.04,50.98 105.62,50.98 104.83,51.76 104.83,52.35 103.82,53.36 103.82,54.61 103.56,54.86 103.56,55.4 v1(104,55.83)
  BOTTOM w0.089: v1(104,55.83) 103.64,56.19 U22.BC15
  BOTTOM w0.14: R178.2 v1(151.01,51.56) 151.08,51.63 R181.2
MBCLK: length 170.7
  TOP w0.14: PD2.1 103.03,15.54 v1(102.65,15.92) ; v1(27.41,35.94) 30.84,35.94 31.51,36.61 U14.110 31.51,40.8 31.78,41.07 31.78,42.11 31.92,42.25 R250.1 ; PR105.2 v1(149.13,11.86)
  IN1 w0.089: v1(27.41,35.94) 26.8,35.32 26.8,31.75 27.25,31.29 27.29,31.29 28.71,29.87 28.71,25.08 32.67,21.13 32.67,19.83 33.73,18.77 33.73,17.52 37.65,13.59 47.34,13.59 49.34,11.59 58.54,11.59 60.44,9.68 73.97,9.68 74.56,9.09 82,9.09 83.08,10.18 88.5,10.18 88.82,10.5 88.82,13.61 90.88,15.67 93.28,15.67 93.55,15.4 98.5,15.4 98.84,15.74 102.46,15.74 v1(102.65,15.92) 103.18,16.45 110.91,16.45 111.67,15.69 115.4,15.69 115.8,16.09 119.5,16.09 120.45,15.14 120.45,14.53 122.91,12.06 133.18,12.06 134.69,10.56 135.66,10.56 136.05,10.17 136.48,10.17 136.87,10.56 138.04,10.56 138.61,9.99 138.61,8.8 139.33,8.08 146.33,8.08 148.73,10.48 148.73,11.46 v1(149.13,11.86)
  BOTTOM w0.14: v1(102.65,15.92) 102.14,16.43 100.62,16.43 100.36,16.18 PC234.1 PR262.2
MBCLK_R: length 2.4
  BOTTOM w0.14: PR262.1 v1(99.35,14.02) 99.35,14.01 PJ16.4
MBDATA: length 168.3
  TOP w0.14: v1(26.73,35.91) 26.75,35.91 27.23,36.39 29.85,36.39 31.11,37.66 U14.111 31.11,41.66 R267.1 ; PD3.1 104.98,15.49 104.55,15.92 v1(103.92,15.92) ; PR106.2 v1(149.13,10.84)
  IN1 w0.089: v1(149.13,10.84) 149.13,10.39 146.47,7.74 139.18,7.74 138.23,8.7 138.23,9.88 137.9,10.21 137.01,10.21 136.63,9.83 135.9,9.83 135.52,10.21 134.55,10.21 133.04,11.72 122.77,11.72 120.1,14.39 120.1,15 119.36,15.75 115.94,15.75 115.54,15.35 111.53,15.35 110.76,16.11 104.11,16.11 v1(103.92,15.92) 103.39,15.4 98.98,15.4 98.64,15.05 93.41,15.05 93.14,15.32 91.02,15.32 89.17,13.47 89.17,10.36 88.64,9.83 83.22,9.83 82.14,8.75 74.41,8.75 73.82,9.34 60.3,9.34 58.39,11.24 49.2,11.24 47.19,13.25 37.51,13.25 33.38,17.38 33.38,18.41 32.32,19.47 32.32,20.99 31.54,21.77 30.63,21.77 30.14,22.26 30.14,23.17 28.37,24.94 28.37,29.3 27.52,30.15 27.3,30.15 26.45,31 26.45,35.63 v1(26.73,35.91)
  BOTTOM w0.14: PR263.2 102.01,15.68 PC235.1 103.17,15.17 v1(103.92,15.92)
MBDATA_R: length 2.4
  BOTTOM w0.14: PR263.1 101.38,14.39 101.35,14.36 v1(101.35,14.02) PJ16.3
MDI_0+: length 6.6
  TOP w0.14: U3.1 33.46,88.44 33.5,88.49 33.67,88.49 34.19,87.96 35.48,87.96 v1(35.96,87.48) 36.44,87.96 36.77,87.96 v1(36.98,87.74)
  BOTTOM w0.14: U20.2 36.28,87.62 36.64,87.99 36.74,87.99 v1(36.98,87.74)
MDI_0-: length 6.6
  TOP w0.14: v1(36.98,88.5) 36.75,88.27 36.44,88.27 v1(35.96,88.75) 35.48,88.27 34.32,88.27 33.79,88.79 33.5,88.79 33.46,88.84 U3.2
  BOTTOM w0.14: v1(36.98,88.5) 36.77,88.29 36.65,88.29 36.32,88.62 U20.3
MDI_1+: length 7.5
  TOP w0.14: U3.4 33.46,89.64 33.5,89.68 34.19,89.68 v1(34.69,89.18) 35.19,89.68 35.96,89.68 36.42,90.14 36.42,90.83 36.56,90.97 36.83,90.97 v1(37.06,90.73)
  BOTTOM w0.14: U20.5 36.34,90.62 36.67,90.96 36.84,90.96 v1(37.06,90.73)
MDI_1-: length 7.5
  TOP w0.14: U3.5 33.46,90.04 33.51,89.98 34.23,89.98 v1(34.69,90.45) 35.16,89.98 35.83,89.98 36.12,90.27 36.12,90.96 36.43,91.27 36.84,91.27 v1(37.06,91.49)
  BOTTOM w0.14: v1(37.06,91.49) 36.83,91.26 36.71,91.26 36.35,91.62 U20.6
MDI_2+: length 8.8
  TOP w0.14: U3.6 33.46,90.44 33.5,90.49 33.8,90.49 35.41,92.09 35.41,92.31 v1(35.89,92.79) 35.41,93.27 35.41,93.58 35.76,93.94 36.82,93.94 v1(37.06,93.69)
  BOTTOM w0.14: U20.8 36.37,93.62 36.66,93.91 36.84,93.91 v1(37.06,93.69)
MDI_2-: length 8.8
  TOP w0.14: U3.7 33.46,90.84 33.5,90.79 33.68,90.79 35.1,92.21 35.1,92.31 v1(34.62,92.79) 35.1,93.27 35.1,93.71 35.64,94.24 36.84,94.24 v1(37.06,94.45)
  BOTTOM w0.14: U20.9 36.29,94.62 36.69,94.22 36.82,94.22 v1(37.06,94.45)
MDI_3+: length 11.7
  TOP w0.14: U3.9 32.04,92.68 31.99,92.73 31.99,92.97 32.14,93.11 33.42,93.11 33.82,93.51 33.82,93.87 v1(34.3,94.34) 33.81,94.82 33.81,95.1 34.63,95.91 34.63,96.52 35.16,97.06 37,97.06 37.07,96.99 v1(37.07,96.74)
  BOTTOM w0.14: U20.11 36.36,96.62 36.77,97.04 37,97.04 37.07,96.97 v1(37.07,96.74)
MDI_3-: length 11.7
  TOP w0.14: v1(37.07,97.5) 36.92,97.36 35.04,97.36 34.32,96.64 34.32,96.04 33.51,95.23 33.51,94.82 v1(33.03,94.34) 33.52,93.85 33.52,93.64 33.3,93.42 32.01,93.42 31.69,93.09 31.69,92.73 31.64,92.68 U3.10
  BOTTOM w0.14: v1(37.07,97.5) 36.9,97.34 36.61,97.34 36.33,97.62 U20.12
MDSI_RCOMP: length 6.9
  BOTTOM w0.089: U22.AL5 108.35,61.3 108.53,61.12 108.76,61.12 108.88,61.24 109.07,61.24 109.19,61.12 109.4,61.12 109.8,61.53 110.58,61.53 110.93,61.17
  BOTTOM w0.152: 110.93,61.17 110.97,61.14 112.22,61.14 112.56,60.8 R507.1
ME_WR#: length 45.9
  TOP w0.127: R251.2 37.14,44.21 37.14,44.22 37.45,44.52 39.71,44.52 40.38,45.2 42.02,45.2 42.94,46.11 44.7,46.11 45.19,46.61 45.89,46.61 46.99,45.5 v1(47.03,45.5)
  BOTTOM w0.14: Q33.2 66.96,64.69 64.22,61.95 63.26,61.95 60.48,59.17 58.83,59.17 56.07,56.41 56.07,54.76 54.98,53.67 54.56,53.67 54.13,53.25 54.13,46.89 53.6,46.35 50.27,46.35 50.07,46.15 47.67,46.15 47.03,45.52 v1(47.03,45.5)
MEM_CH0_RCOMP: length 2.8
  TOP w0.381: v1(96.89,57.25) 97.46,56.68 97.46,55.96 97.86,55.56 R175.1
  BOTTOM w0.165: v1(96.89,57.25) U22.AY29
MEM_CH1_RCOMP: length 1.8
  TOP w0.381: v1(98.67,57.25) 98.36,57.56 98.36,57.63 97.9,58.1 R170.1
  BOTTOM w0.089: v1(98.67,57.25) U22.AY27
MIC2-VREFO: length 12.4
  TOP w0.203: U16.29 180.08,22.05 v1(180.24,22.2)
  TOP w0.508: R335.1 184.95,17.44 v1(185.45,16.94) ; v1(185.83,17.45) 185.83,17.32 v1(185.45,16.94) ; v1(185.45,16.94) 184.95,16.44 R338.1
  IN1 w0.508: v1(185.45,16.94) 184.56,16.94 183.93,17.58 183.29,17.58 182.79,18.08 182.79,21 181.59,22.2 v1(180.24,22.2)
MX0: length 31.8
  TOP w0.127: v1(43.4,15.29) 43.14,15.02 CP6.1 ; 34.31,23.58 34.31,23.17 v1(34.7,22.78)
  TOP w0.14: U14.58 34.31,23.58 ; v1(34.7,22.78) 35.24,22.25 37.97,22.25 38.18,22.46 38.63,22.46 38.87,22.22 38.87,21.88 RP1.9 39.2,21.9 39.2,22.27 38.56,22.91 v1(38.44,22.91)
  IN1 w0.089: v1(43.4,15.29) 43.21,15.48 40.21,15.48 39.06,16.63 39.06,22.28 v1(38.44,22.91)
  BOTTOM w0.127: v1(43.4,15.29) 43.4,14.46 44.61,13.26 44.61,12.37 42.08,9.84 38.57,9.84 CN16.1
MX1: length 36.7
  TOP w0.127: v1(43.4,16.05) 42.35,15
  TOP w0.14: U14.59 34.71,23.58 35.78,22.52 37.41,22.52 38.25,23.36 38.62,23.36 38.89,23.09 38.89,22.96 39.5,22.35 39.5,21.88 RP1.8 39.78,21.85 39.78,22.48 39.39,22.87 v1(39.39,23.1) ; v1(37.4,7.92) 37.4,9.07 38.12,9.79 39.11,9.79 40.09,10.77 43.02,10.77 43.54,11.29 43.54,13.34 43.35,13.52 42.69,13.52 42.35,13.87 CP6.3 42.35,15
  IN1 w0.089: v1(43.4,16.05) 43.02,15.67 40.29,15.67 39.25,16.71 39.25,22.23 39.39,22.36 v1(39.39,23.1)
  BOTTOM w0.14: v1(37.4,7.92) 37.4,7.92 CN16.2
MX2: length 29.2
  TOP w0.14: v1(40.34,23.01) 40.44,22.91 40.44,21.88 RP1.7 40.14,21.88 40.14,22.55 39.86,22.83 39.86,23.27 39.5,23.63 38.14,23.63 37.29,22.78 35.91,22.78 35.11,23.58 U14.60 ; v1(36.4,8.81) 37.79,10.21 39.01,10.21 40.21,11.41 40.21,13.31 40.42,13.51 41.21,13.51 41.54,13.84 CP6.5 41.54,15.06 40.13,16.47 40.13,17.16 39.74,17.55 39.73,17.55 v1(39.65,17.62)
  IN1 w0.089: v1(40.34,23.01) 39.65,22.32 v1(39.65,17.62)
  BOTTOM w0.14: v1(36.4,8.81) CN16.3
MX3: length 31.3
  TOP w0.14: v1(35.4,7.92) 35.4,8.45 37.42,10.48 38.9,10.48 39.94,11.51 39.94,13.41 40.32,13.79 40.6,13.79 40.75,13.94 CP6.7 40.75,15.21 39.67,16.29 v1(39.67,16.96) ; v1(41.26,22.99) 41.26,22.99 41.13,22.86 41.13,21.94 40.93,21.74 RP1.6 40.8,21.85 40.8,23.19 40.53,23.46 40.04,23.46 39.61,23.89 38.03,23.89 37.18,23.05 36.05,23.05 35.51,23.58 U14.61
  IN1 w0.089: v1(39.67,16.96) 40.09,17.38 40.09,21.82 41.26,22.99 v1(41.26,22.99)
  BOTTOM w0.14: CN16.4 35.4,7.92 v1(35.4,7.92)
MX4: length 32.7
  TOP w0.14: v1(34.4,8.81) 35.38,8.81 37.31,10.74 38.79,10.74 39.67,11.62 39.67,13.5 39.38,13.79 39.07,13.79 38.94,13.92 CP5.1 38.94,16.95 39.15,17.16 39.15,17.84 39.92,18.61 39.92,19.15 40.29,19.52 RP1.4 40.29,20.62 40.55,20.88 41.31,20.88 41.43,21 41.43,22.53 42.2,23.29 42.2,25.17 41.19,26.18 40.11,26.18 39.28,25.34 39.28,24.43 39,24.16 37.92,24.16 37.07,23.32 36.18,23.32 35.91,23.58 U14.62
  BOTTOM w0.14: v1(34.4,8.81) CN16.5
MX5: length 30.7
  TOP w0.14: U14.63 36.31,25.24 35.99,25.56 v1(35.06,25.56) ; v1(33.4,7.92) 33.4,8.45 34.21,9.26 35.46,9.26 37.2,11.01 38.68,11.01 39.4,11.73 39.4,13.38 39.28,13.51 38.51,13.51 38.16,13.87 CP5.3 38.16,16.58 38.89,17.31 38.89,17.95 39.66,18.72 RP1.3 39.66,20.45 39.33,20.77 37.4,20.77 v1(36.86,21.31)
  IN1 w0.089: v1(35.06,25.56) 35.06,23.11 v1(36.86,21.31)
  BOTTOM w0.14: v1(33.4,7.92) 33.4,7.92 CN16.6
MX6: length 27
  TOP w0.127: U14.64 36.93,24.11 v1(37.23,24.11)
  TOP w0.14: v1(32.4,8.81) 33.38,8.81 34.1,9.53 34.96,9.53 36.16,10.73 36.16,13.34 36.33,13.51 37.12,13.51 37.34,13.74 CP5.5 37.34,17.33 38.77,18.76 38.77,19.77 RP1.2 39.28,19.77 39.28,18.72 38.43,17.88 v1(38.43,17.78)
  IN1 w0.089: v1(37.23,24.11) 37.23,22.66 38.61,21.28 38.61,17.96 v1(38.43,17.78)
  BOTTOM w0.14: v1(32.4,8.81) CN16.7
MX7: length 31.6
  TOP w0.127: v1(37.61,25.47) 37.61,25.83 37.76,25.98 U14.65
  TOP w0.14: v1(31.4,7.92) 31.4,8.91 31.75,9.26 33.46,9.26 33.99,9.8 34.85,9.8 35.89,10.84 35.89,13.52 36.19,13.82 36.46,13.82 36.56,13.92 CP5.7 36.76,14.51 36.76,17.13 38.39,18.75 RP1.1 38.39,20.32 38.2,20.5 37.03,20.5 36.22,21.3 v1(36.22,21.31)
  IN1 w0.089: v1(37.61,25.47) 36.81,26.27 34.87,26.27 34.63,26.03 34.63,22.9 v1(36.22,21.31)
  BOTTOM w0.14: CN16.8 31.4,7.92 v1(31.4,7.92)
MY0: length 27.4
  TOP w0.14: v1(13.4,7.92) 13.4,8.72 17.41,12.72 17.41,13.51 17.69,13.79 18.02,13.79 18.14,13.92 CP1.7 18.14,15.36 19.88,17.1 23.49,17.1 24.67,18.27 25.9,18.27 26.53,18.91 26.53,22.32 25.51,23.34 U14.36
  BOTTOM w0.14: v1(13.4,7.92) CN16.26
MY1: length 25.3
  TOP w0.14: U14.37 25.91,23.32 26.8,22.43 26.8,18.8 26.01,18.01 24.78,18.01 23.6,16.83 19.99,16.83 18.93,15.77 CP1.5 18.93,13.87 18.57,13.51 17.81,13.51 17.69,13.38 17.69,12.23 v1(14.4,8.94)
  BOTTOM w0.14: v1(14.4,8.94) CN16.25
MY2: length 29.5
  TOP w0.14: v1(15.4,7.92) 15.4,8.45 17.07,10.12 19.56,10.12 21.01,11.57 21.01,13.36 20.86,13.51 19.97,13.51 19.74,13.74 CP1.3 19.74,16.2 20.1,16.56 23.71,16.56 24.89,17.74 26.12,17.74 27.07,18.69 27.07,22.54 26.31,23.29 U14.38
  BOTTOM w0.14: v1(15.4,7.92) 15.4,7.92 CN16.24
MY3: length 25.4
  TOP w0.14: U14.39 26.71,23.27 27.33,22.65 27.33,18.58 24.78,16.03 22.35,16.03 21.21,14.88 20.73,14.88 20.53,14.68 CP1.1 20.53,13.97 20.66,13.84 21.04,13.84 21.27,13.61 21.27,11.46 19.67,9.85 18.09,9.85 17.05,8.81 v1(16.4,8.81)
  BOTTOM w0.14: v1(16.4,8.81) CN16.23
MY4: length 25
  TOP w0.14: U14.40 27.11,23.25 27.6,22.76 27.6,18.47 24.89,15.76 22.96,15.76 22.21,15.01 CP2.7 22.21,14.02 22,13.82 21.91,13.82 21.54,13.45 21.54,11.35 19.78,9.59 18.21,9.59 17.4,8.78 v1(17.4,7.92)
  BOTTOM w0.14: v1(17.4,7.92) CN16.22
MY5: length 22.5
  TOP w0.14: U14.41 27.51,23.23 27.87,22.87 27.87,18.36 25,15.49 23.96,15.49 22.99,14.53 CP2.5 22.99,13.61 22.89,13.51 21.98,13.51 21.81,13.34 21.81,11.24 19.89,9.32 18.91,9.32 v1(18.4,8.81)
  BOTTOM w0.14: v1(18.4,8.81) CN16.21
MY6: length 25.6
  TOP w0.14: U14.42 27.91,23.2 28.13,22.98 28.13,18.24 25.11,15.22 24.46,15.22 23.81,14.57 CP2.3 23.81,13.61 23.91,13.51 24.82,13.51 25.05,13.28 25.05,11.73 23.67,10.36 21.3,10.36 19.4,8.45 v1(19.4,7.92)
  BOTTOM w0.14: v1(19.4,7.92) CN16.20
MY7: length 22.2
  TOP w0.14: v1(20.4,8.81) 21.38,8.81 22.65,10.08 23.9,10.08 25.33,11.5 25.33,13.59 25.08,13.84 24.77,13.84 24.59,14.02 CP2.1 24.59,14.33 28.4,18.13 28.4,23.29 28.31,23.38 U14.43
  BOTTOM w0.14: v1(20.4,8.81) CN16.19
MY8: length 23.1
  TOP w0.14: U14.44 28.71,23.27 28.69,23.24 28.69,17.02 26.72,15.05 26.71,15.05 26.4,14.73 CP3.7 26.4,13.89 26.3,13.79 25.89,13.79 25.66,13.56 25.66,11.33 24.13,9.8 22.74,9.8 21.4,8.45 21.4,7.7 v1(21.39,7.69)
  BOTTOM w0.14: CN16.18 21.4,7.93 21.39,7.92 v1(21.39,7.69)
MY9: length 20.7
  TOP w0.14: U14.45 29.11,23.21 28.95,23.05 28.95,16.91 27.18,15.14 CP3.5 27.18,13.74 26.96,13.51 26.07,13.51 25.94,13.38 25.94,11.23 24.24,9.53 23.11,9.53 v1(22.4,8.81)
  BOTTOM w0.14: v1(22.4,8.81) CN16.17
MY10: length 24.1
  TOP w0.14: U14.46 29.51,23.23 29.22,22.94 29.22,16.8 28,15.57 CP3.3 28,13.74 28.23,13.51 29.09,13.51 29.22,13.38 29.22,11.72 28.09,10.59 25.94,10.59 24.61,9.26 24.11,9.26 23.4,8.55 v1(23.4,7.92)
  BOTTOM w0.14: v1(23.4,7.92) CN16.16
MY11: length 22.2
  TOP w0.14: U14.51 31.51,23.53 31.99,23.06 31.99,20.85 29.98,18.85 29.98,16.34 28.78,15.14 CP3.1 28.78,13.97 28.94,13.82 29.28,13.82 29.48,13.61 29.48,11.61 28.2,10.32 26.05,10.32 24.54,8.81 v1(24.4,8.81)
  BOTTOM w0.14: v1(24.4,8.81) CN16.15
MY12: length 23
  TOP w0.14: v1(25.4,7.92) 25.4,9.03 26.42,10.06 28.33,10.06 29.75,11.48 29.75,13.59 29.98,13.82 30.33,13.82 30.46,13.94 CP4.7 30.46,14.96 30.25,15.17 30.25,18.74 32.26,20.76 32.26,23.21 31.91,23.57 U14.52
  BOTTOM w0.14: v1(25.4,7.92) CN16.14
MY13: length 21.5
  TOP w0.14: U14.53 32.31,23.55 32.54,23.32 32.54,20.66 30.52,18.63 30.52,15.36 31.25,14.63 CP4.5 31.25,13.61 31.15,13.51 30.23,13.51 30.05,13.33 30.05,11.28 28.57,9.79 26.92,9.79 26.4,9.27 v1(26.4,8.81)
  BOTTOM w0.14: v1(26.4,8.81) CN16.13
MY14: length 24.9
  TOP w0.14: U14.54 32.71,23.57 32.81,23.47 32.81,18.59 33.63,17.78 33.63,15.48 33.2,15.05 32.56,15.05 32.06,14.55 CP4.3 32.06,13.74 32.29,13.51 33.08,13.51 33.25,13.34 33.25,12 31.58,10.33 29.49,10.33 28.48,9.32 27.85,9.32 27.4,8.87 v1(27.4,7.92)
  BOTTOM w0.14: v1(27.4,7.92) 27.4,7.92 CN16.12
MY15: length 21.2
  TOP w0.14: U14.55 33.11,18.67 33.89,17.89 33.89,15.37 32.85,14.33 CP4.1 32.85,13.94 32.98,13.82 33.15,13.82 33.52,13.45 33.52,11.89 31.69,10.06 29.7,10.06 28.45,8.81 v1(28.4,8.81)
  BOTTOM w0.14: v1(28.4,8.81) CN16.11
MY16: length 22.4
  TOP w0.14: U14.56 33.51,23.47 33.38,23.34 33.38,18.78 34.63,17.53 34.63,13.81 C298.2 33.78,12.96 33.78,11.78 31.8,9.8 29.9,9.8 29.4,9.3 v1(29.4,7.92)
  BOTTOM w0.14: v1(29.4,7.92) 29.4,7.92 CN16.10
MY17: length 21.9
  TOP w0.14: U14.57 33.91,23.49 33.65,23.23 33.65,18.89 35.08,17.45 C299.2 35.62,13.49 35.62,10.98 34.7,10.06 33.8,10.06 33.27,9.53 30.65,9.53 30.4,9.28 v1(30.4,8.81)
  BOTTOM w0.14: v1(30.4,8.81) CN16.9
NBSWON#: length 34.7
  TOP w0.127: R325.2 17.43,20.5 ; v1(22.83,22.89) 22.59,22.66 21.11,22.66 20.9,22.87 19.84,22.87 19.25,22.27 18.78,22.27 v1(18.14,21.64) 18.14,21.28 18.32,21.11 C278.1 ; R258.1 32.64,42.44 32.64,41.39 32.71,41.31 U14.107 32.71,39.29 32.32,38.9 32.32,38.17 32.74,37.75 33.15,37.75 33.46,37.44 33.46,34.7 v1(32.77,34.01)
  TOP w0.14: 17.43,20.5 C278.1
  BOTTOM w0.127: R554.1 31.27,31.92 31.27,32.13 32.77,33.63 v1(32.77,34.01)
  BOTTOM w0.14: v1(22.83,22.89) 24.24,24.31 27.02,24.31 28.63,25.92 28.63,27.92 30.19,29.48 30.19,29.71 C443.2 R554.1
NEW_CLK_24M_DEBUG: length 27
  IN3 w0.127: v1(38.69,40.4) 38.5,40.58 34.68,40.58 34.57,40.68 34.57,40.96 34.66,41.05 39,41.05 39.66,40.4 v1(39.66,40.05)
  BOTTOM w0.127: v1(38.69,40.4) 39.53,41.24 R545.1
  BOTTOM w0.14: v1(39.66,40.05) 38.12,38.52 38.12,32.96 36.99,31.83 36.99,28.93 36.15,28.09 CN10.60
NEW_LAD0: length 35.1
  IN3 w0.127: v1(35.85,57.07) 37.12,55.81 37.12,49.76 37.61,49.27 37.61,47.69 39.54,45.76 39.54,44.71 41.27,42.98 v1(41.27,42.31)
  BOTTOM w0.127: R522.2 v1(35.85,57.07) ; 36.73,31.95 36.73,29.13 35.65,28.05
  BOTTOM w0.14: v1(41.27,42.31) 41.26,42.31 40.41,41.47 40.41,41.45 37.85,38.89 37.85,33.07 36.73,31.95 ; 35.65,28.05 CN10.58
NEW_LFRAME#_C: length 29.2
  IN3 w0.127: v1(40.14,40.46) 39.24,41.36 39.24,43.06 36.28,46.02 36.28,48.73 35.8,49.22 35.8,50.54 v1(35.08,51.26)
  BOTTOM w0.127: R534.1 35.56,51.26 v1(35.08,51.26) ; 36.65,28.21 37.27,28.82 37.27,31.73
  BOTTOM w0.14: 36.65,28.21 CN10.62 ; v1(40.14,40.46) 40.14,39.9 38.39,38.15 38.39,32.85 37.27,31.73
NGFF_SATA_DET#: length 7.8
  TOP w0.127: Q26.2 54.9,8.18 54.77,8.3 53.55,8.3 53,7.75 R383.1 53,6.92 v1(52.86,6.78) 52.48,7.16 51.85,7.16 51.58,7.43 v1(51.58,7.6)
  BOTTOM w0.127: CN15.10 52.35,6.83 v1(51.58,7.6)
NUMLED#: length 2.4
  TOP w0.127: U14.80 39.67,31.98 v1(39.71,32.02) 40.57,32.02 R292.2
ODD_POWER: length 1.4
  TOP w0.14: TP38.1 39.57,28.23 39.26,28.23 39.11,28.38 U14.71
PANEL_LED_EN: length 199.3
  TOP w0.127: PR34.1 160.05,65.07 160.31,64.82 PR37.1 160.93,64.32 161.2,64.06 164.32,64.06 164.7,64.44 165.89,64.44 166.4,64.95 v1(166.53,64.95) ; U14.78 39.37,31.18 40.19,30.36 46.42,30.36 v1(47.02,30.96)
  IN3 w0.127: v1(166.53,64.95) 169.2,64.95 170.59,63.55 170.59,60.84 170.34,60.58 170.34,57.07 168.82,55.55 168.82,53.51 164.17,48.86 161.89,46.59 161.89,37.84 159.73,35.68 159.73,31.63 159.18,31.08 158.16,31.08 157.37,31.86 149.44,31.86 148.95,31.37 147.65,31.37 146.99,30.71 143.9,30.71 143.52,30.33 141.91,30.33 141.59,30.01 141.59,28.78 140.6,27.8 128.42,27.8 127.24,26.61 127.24,23.54 125.3,21.6 121.55,21.6 119.35,19.39 119.35,19.34 116,15.99 104.71,15.99 103.95,15.23 93.99,15.23 93.1,16.11 87.11,16.11 85.54,14.54 75.09,14.54 73.23,12.69 57.14,12.69 54.54,15.28 49.27,15.28 47.51,17.04 47.51,30.47 v1(47.02,30.96)
  BOTTOM w0.127: R498.1 166.78,64.69 v1(166.53,64.95)
PCBEEP: length 2
  TOP w0.14: C307.1 182.15,13.39 182.15,14.06 181.68,14.53 U16.12
PCBEEP_EC: length 168.1
  TOP w0.14: v1(24.42,23.01) 24.42,23.01 24.71,23.3 U14.34 ; D32.2 172,5.76 172.63,5.13 v1(172.63,3.99)
  IN1 w0.089: v1(24.42,23.01) 24.42,18.94 29.64,13.72 29.64,11 33.48,7.17 64.91,7.17 65.5,6.58 83.04,6.58 83.61,7.14 119.09,7.14 121.35,9.4 124.12,9.4 124.77,10.06 132.44,10.06 136.55,5.95 143.05,5.95 143.81,5.19 154.92,5.19 155.65,5.92 158.63,5.92 160.59,3.96 172.6,3.96 v1(172.63,3.99)
PCH_ACPRESENT: length 5.6
  TOP w0.14: TP63.1 43.3,33.44 39.54,33.44 39.4,33.58 U14.84
PCH_AZ_CODEC_RST_R#: length 10.7
  TOP w0.127: Q13.3 v1(164.88,21.77) 164.88,20.6 165.16,20.32 166.28,20.32 166.53,20.06 166.53,16.05 167.04,15.54 D27.1
PCH_BATLOW#: length 2.7
  TOP w0.127: C85.2 R99.2 89.22,71.3 v1(88.8,70.89)
  BOTTOM w0.089: U22.J48 89.1,71.19 v1(88.8,70.89)
PCH_BKLTCTL: length 116.9
  TOP w0.14: R86.1 v1(166.53,74.84) 167.29,74.84 R622.1 167.84,74.97 167.98,75.11 v1(167.98,76.15)
  IN1 w0.089: v1(115.77,97.12) 115.49,96.84 115.49,94.12 114.75,93.37 114.75,92.6 112.08,89.93 109.62,89.93 107.34,87.65 105.93,87.65 104.66,86.37 99.4,86.37 97.38,88.38 97.38,88.75 96.6,89.54 95.36,89.54 94.77,88.95 v1(94.77,88.82)
  IN3 w0.127: v1(167.98,76.15) 167.72,76.15 166.88,76.99 153.84,76.99 152.87,77.96 151.87,77.96 148.18,81.65 145.01,81.65 142.75,83.9 124.22,83.9 123.86,84.26 123.35,84.26 122.97,84.64 122.97,91.63 121.56,93.03 121.56,94.04 118.4,97.2 115.86,97.2 v1(115.77,97.12)
  BOTTOM w0.089: U22.B41 91.77,74.8 91.77,75.05 91.47,75.35 91.47,76.24
  BOTTOM w0.14: v1(94.77,88.82) 94.77,88.19 94.96,88 94.96,86.19 94.5,85.73 92.39,85.73 90.63,83.96 90.63,82.33 89.93,81.63 89.93,80.8 90.16,80.57 90.16,77.55 91.47,76.24
PCH_BKLTEN: length 132
  TOP w0.127: v1(164.27,66.11) 164.19,66.19 v1(163.1,66.19) 162.72,66.19 162.45,66.46 162.21,66.46 R621.1 160.83,66.72 R115.1
  IN1 w0.089: v1(95.36,88.52) 95.76,88.52 96.11,88.87 96.48,88.87 96.85,88.5 96.85,88.16 99.17,85.84 106.98,85.84 109.15,88 112.99,88 114.08,86.92 114.48,86.92 114.76,87.19 114.76,92.12 115.09,92.46 115.09,93.23 115.89,94.03 116.68,94.03 116.97,94.32 116.97,95.71 116.36,96.32 v1(116.36,96.37)
  IN3 w0.127: v1(116.36,96.37) 116.38,96.37 116.81,96.81 118.26,96.81 121.18,93.88 121.18,92.87 122.59,91.47 122.59,83.87 123.08,83.37 142.74,83.37 144.85,81.27 148.03,81.27 149.83,79.46 149.83,77.72 150.94,76.6 164.41,76.6 168.01,73 168.01,69.2 165.37,66.56 164.64,66.56 164.27,66.18 v1(164.27,66.11)
  BOTTOM w0.089: 91.79,75.61 92.1,75.31 92.1,74.88 92.21,74.72 92.21,74.59 U22.C40
  BOTTOM w0.14: 91.79,75.61 91.79,76.24 90.39,77.64 90.39,80.69 90.16,80.93 90.16,81.54 91.02,82.4 91.02,83.8 91.62,84.4 91.63,84.4 92.56,85.34 94.67,85.34 95.36,86.03 v1(95.36,88.52)
PCH_BLON: length 2.1
  TOP w0.127: R103.1 R621.2 161.06,67.49 v1(160.94,67.61)
PCH_BLON_EC: length 196.8
  TOP w0.127: v1(164.9,66.11) 164.25,66.77 163.25,66.77 163.01,67.01 R107.1 ; U14.88 39.1,35.18 39.62,34.66 43.99,34.66 45.14,33.5 47.05,33.5 v1(47.38,33.17) v1(48.19,32.36)
  IN3 w0.127: v1(164.9,66.11) 165.32,65.7 165.32,64.76 165.58,64.5 169.26,64.5 170.34,63.42 170.34,60.94 170.09,60.69 170.09,57.18 168.56,55.65 168.56,53.62 163.91,48.97 161.64,46.69 161.64,37.95 159.48,35.79 159.48,31.74 159.07,31.33 158.26,31.33 157.48,32.12 149.33,32.12 148.84,31.63 147.55,31.63 146.89,30.97 143.8,30.97 143.42,30.59 141.81,30.59 141.34,30.12 141.34,28.89 140.5,28.05 128.32,28.05 126.98,26.72 126.98,23.64 125.19,21.85 121.43,21.85 119.09,19.52 119.09,19.44 117.42,17.77 112.46,17.77 111.07,16.37 87.01,16.37 85.48,14.84 75.03,14.84 73.13,12.94 57.24,12.94 54.65,15.54 49.38,15.54 47.77,17.14 47.77,31.94 v1(48.19,32.36)
PCH_BLON_R: length 10.5
  TOP w0.127: R107.2 162.85,68.35 162.85,69.14 162.71,69.27 R103.2 161.84,69.27 161.45,68.88 161.45,68.5 161.14,68.19 160.74,68.19 160.43,68.5 v1(160.43,69.14) 160.43,69.91 160.2,70.14 R101.1 159.54,70.6 159.54,71.17 159.82,71.44 159.82,71.78 160.11,72.07 160.11,72.65 160.41,72.95 Q7.5
PCH_BRIGHT: length 2.1
  TOP w0.14: R622.2 167.42,76.4 v1(167.77,76.76)
  BOTTOM w0.14: v1(167.77,76.76) 167.03,76.76 R451.2
PCH_PCIERST#: length 36.3
  TOP w0.127: v1(73.97,64.18) 73.34,64.82 v1(68.61,64.82) 66.33,64.82 64.93,63.42 64.29,63.42 63.79,62.91 R637.1
  IN3 w0.089: 82.33,64.28 84.17,64.28 84.46,64.57 86,64.57 86.4,64.97 86.4,66.49 87.14,67.23 87.54,67.23
  IN3 w0.127: 87.54,67.23 89.38,67.23 91.15,69.01 91.15,71.11 91.55,71.5 v1(91.55,71.52) ; v1(73.97,64.18) 74.61,63.55 76.36,63.55 77.59,64.78 78.33,64.78 78.83,64.28 82.33,64.28
  BOTTOM w0.089: v1(91.55,71.52) 91.39,71.52 U22.H43
PCH_PLTRST#: length 33.3
  TOP w0.127: v1(64.55,63.92) 63.02,63.92 R638.1 63.1,63.61 63.1,62.1 62.9,61.9 U34.2
  IN1 w0.089: v1(64.55,63.92) 64.78,63.92 66.24,65.38 69.6,65.38 71.83,67.61 76.72,67.61 78.58,69.47 79.88,69.47 80.7,70.29 80.7,70.96 81.59,71.85 81.59,74.45 81.44,74.6 v1(81.44,74.62)
  BOTTOM w0.089: U22.D54 86.17,74.21 85.75,74.21 85.38,74.59
  BOTTOM w0.114: 85.38,74.59 81.45,74.59 81.44,74.6 v1(81.44,74.62)
PCH_SPI_CLK: length 21.2
  IN1 w0.089: v1(94.42,87.63) 94.57,87.48 94.57,86.76 94.68,86.65 94.8,86.65 95.02,86.87 95.15,86.87 95.36,86.66 95.36,86.54 95.14,86.32 95.14,86.19 95.34,85.98 95.47,85.98 95.72,86.23 95.81,86.23 96.02,86.02 96.02,85.87 95.8,85.65 95.8,85.53 96.01,85.32 96.13,85.32 96.38,85.57 96.48,85.57 96.68,85.36 96.68,85.21 96.47,84.99 96.47,84.86 96.67,84.65 96.8,84.65 97.03,84.89 97.16,84.89 97.37,84.68 97.37,84.56 97.13,84.32 97.13,84.2 97.34,83.99 97.46,83.99 97.63,84.16 97.79,84.16 97.99,83.95 97.99,83.85 97.8,83.66 97.8,82.85 97.84,82.81 97.84,81.83 v1(97.82,81.81)
  BOTTOM w0.089: U22.B29 97.37,74.7 97.37,75.04 97.65,75.32 97.65,77.18 98.1,77.62 98.1,78.5 98.48,78.88 98.48,79.21 98.08,79.61 98.08,80.92 98.15,80.99 98.15,81.32 97.98,81.49 97.98,81.64 v1(97.82,81.81)
  BOTTOM w0.14: v1(94.42,87.63) 94.2,87.63 93.13,88.7 R394.1
PCH_SPI_CLK_EC: length 19.7
  TOP w0.14: v1(32.87,38.83) 33.05,38.83 33.51,39.28 U14.105
  BOTTOM w0.14: v1(32.87,38.83) 32.87,40.49 31.65,41.71 31.16,41.71 30.39,42.47 29.42,42.47 29.41,42.47 29.24,42.3 25.64,42.3 25.18,41.83 24.29,41.83 24.04,42.09 24.04,43.86 25.05,44.88 TP59.1 26.32,44.25 26.96,44.25 27.26,44.55 U29.6
PCH_SPI_CS0#: length 30.7
  TOP w0.127: v1(86.29,87.3) 86.79,87.8 88.3,87.8 TP1.1 89.19,86.92 R37.1
  IN1 w0.089: v1(96.87,79.78) 96.5,80.15 96.5,80.8 96.22,81.08 96.22,82.29 95.77,82.75 95.77,83.48 92.77,86.48 91.88,86.48 91.5,86.85 86.73,86.85 v1(86.29,87.3)
  BOTTOM w0.089: v1(96.87,79.78) 96.87,78.66 97.21,78.32 97.21,77.99 96.44,77.22 96.44,75.42 96.25,75.23 96.25,74.87 96.24,74.86 96.14,74.72 96.14,74.59 96.24,74.45 96.43,74.26 U22.C31
  BOTTOM w0.127: U21.1 83.07,86.16 84.22,87.3 v1(86.29,87.3)
PCH_SPI_CS1#: length 4.4
  BOTTOM w0.089: U22.C32 95.82,74.59 95.82,74.72 95.7,74.88 95.7,75.23 95.64,75.29 95.64,75.79 96.2,76.35 96.2,77.24 96.81,77.85 TP50.1
PCH_SPI_IO2: length 31.4
  IN1 w0.089: v1(87.31,87.36) 87.61,87.65 92.6,87.65 96.86,83.39 96.86,81.81 v1(96.93,81.74)
  BOTTOM w0.089: U22.A30 97.01,75.09 97.01,75.18 97.19,75.36 97.19,77.21 97.74,77.77 97.74,78.54 97.49,78.79 97.49,79.33 97.63,79.47 97.63,80.1 97.49,80.23 97.49,80.64 97.33,80.8 97.33,81.18 96.93,81.58 v1(96.93,81.74)
  BOTTOM w0.14: v1(87.31,87.36) 87.3,87.34 87.3,87.19 86.6,86.49 84.51,86.49 83.14,85.11 81.67,85.11 80.61,84.06 79.22,84.06 TP47.1 R404.1
PCH_SPI_IO2_R: length 7.1
  BOTTOM w0.14: U21.3 81.08,88.7 80.52,88.13 v1(80.52,87.68) 80.52,86.88 80.25,86.61 79.86,86.61 79.79,86.54 78.92,86.54 78.8,86.42 78.78,86.42 R407.1 78.77,85.66 R404.2
PCH_SPI_IO3: length 17.4
  IN1 w0.089: v1(97.75,81.15) 97.37,81.53 97.37,82.07 97.16,82.28 97.16,83.51 93.96,86.7 v1(93.96,87.07)
  BOTTOM w0.089: U22.C29 97.33,74.26 97.14,74.45 97.04,74.59 97.04,74.72 97.14,74.86 97.2,74.92 97.2,75.11 97.44,75.36 97.44,77.22 97.92,77.69 97.92,78.61 97.67,78.86 97.67,79.26 97.8,79.39 97.8,80.17 97.77,80.2 97.77,81.13 v1(97.75,81.15)
  BOTTOM w0.14: R401.2 93.37,86.28 TP48.1 94.14,86.89 v1(93.96,87.07)
PCH_SPI_IO3_R: length 4.3
  BOTTOM w0.14: R401.1 93,87.6 v1(92.36,88.24) 91.94,87.81 R400.1 90.9,87.81 90.51,87.43 U21.7
PCH_SPI_SI: length 21.2
  IN1 w0.089: v1(96.9,80.42) 97.74,80.42 98.46,81.14 98.46,84.25 94.06,88.65 v1(94.06,88.82)
  BOTTOM w0.089: v1(96.9,80.42) 97.14,80.17 97.14,80.08 97.16,80.06 97.16,80.05 97.27,79.95 97.27,79.61 97.14,79.48 97.14,78.64 97.38,78.39 97.38,77.91 96.68,77.21 96.68,75.41 96.43,75.15 U22.B31
  BOTTOM w0.14: R391.1 TP45.1 94.9,89.92 94.06,89.08 v1(94.06,88.82)
PCH_SPI_SI_EC: length 18.3
  TOP w0.14: U14.102 34.71,39.26 34.37,38.91 34.37,38.22 33.94,37.79 v1(33.94,37.77)
  BOTTOM w0.14: v1(33.94,37.77) 33.91,37.77 33.43,38.25 33.43,40.66 31.86,42.23 31.37,42.23 30.61,42.99 29.2,42.99 29.19,42.99 29.03,42.82 26.11,42.82 R546.1 25.93,43.75 TP60.1 26.39,43.28 U29.5
PCH_SPI_SI_R: length 3.3
  BOTTOM w0.14: U21.5 90.35,89.97 90.74,90.35 v1(91.73,90.35) R391.2
PCH_SPI_SO: length 30.2
  IN1 w0.089: v1(96.9,81.05) 96.51,81.44 96.51,82.76 96.57,82.81 96.57,83.26 93.06,86.77 92,86.77 91.52,87.25 v1(88.01,87.25)
  BOTTOM w0.089: v1(96.9,81.05) 97.16,80.79 97.16,80.73 97.31,80.57 97.31,80.16 97.45,80.02 97.45,79.54 97.31,79.41 97.31,78.71 97.56,78.47 97.56,77.84 96.93,77.21 96.93,75.41 96.61,75.08 96.61,74.88 96.72,74.72 96.72,74.59 U22.C30
  BOTTOM w0.14: R410.1 80.19,84.5 TP49.1 81.19,85.49 83.03,85.49 84.39,86.85 86.47,86.85 86.8,87.18 86.8,87.57 87.07,87.84 87.72,87.84 88.01,87.55 v1(88.01,87.25)
PCH_SPI_SO_EC: length 17.1
  TOP w0.14: U14.103 34.31,39.2 33.91,38.8 v1(33.91,38.4)
  IN1 w0.089: v1(33.91,38.4) 33.91,44.13 v1(35.49,45.71)
  BOTTOM w0.14: U29.2 34.79,45.82 35.37,46.4 TP58.1 35.97,46.4 37.36,45.02 R543.1 37.07,44.75 36.11,45.71 v1(35.49,45.71)
PCH_SPI_SO_R: length 3.5
  BOTTOM w0.14: U21.2 81.44,87.43 80.93,86.92 80.93,86.76 80.44,86.27 80.14,86.27 v1(80,86.13) 80.04,86.09 R410.2
PCH_SUS_STAT#: length 17.8
  TOP w0.127: v1(87.1,72.84) 86.77,72.51 86.77,72.31 86.27,71.8 83.09,71.8 v1(82.36,71.08) ; v1(79.87,65.51) 78.71,65.51 R127.2
  IN3 w0.127: v1(79.87,65.51) 80.31,65.95 81.18,65.95 81.64,65.49 83.38,65.49 83.6,65.71 83.6,66.72 82.98,67.35 82.98,68.55 82.36,69.16 v1(82.36,71.08)
  BOTTOM w0.089: U22.E52 v1(87.1,72.84)
PCH_SUSPWRDNACK: length 93.5
  TOP w0.14: v1(46.62,39.1) 45.99,39.1 45.86,38.97 42.78,38.97 42.25,39.5 39.26,39.5 38.8,39.04 36.1,39.04 35.21,38.15 35.21,34.85 33.92,33.56 25.93,33.56 25.7,33.8 24.51,33.8 23.49,32.78 U14.15
  IN1 w0.089: v1(46.62,39.1) 46.62,41.33 47.68,42.4 47.68,43.8 47.43,44.05 47.43,45.88 47.9,46.35 53.18,46.35 55.38,48.56 55.38,49.18 56.95,50.74 56.95,53.85 58.57,55.47 58.57,57.39 63.52,62.34 64.89,62.34 67.52,64.97 69.67,64.97 71.24,66.54 76.14,66.54 78.72,69.12 79.63,69.12 80.02,69.12 81.05,70.14 81.05,70.81 81.93,71.7 81.93,72.55 v1(83.34,73.96)
  BOTTOM w0.089: U22.F54 86.29,73.01 85.82,73.01 85.69,72.88
  BOTTOM w0.14: v1(83.34,73.96) 82.72,73.96 R463.2 82.59,73.84 82.92,73.51 83.98,73.51 84.6,72.88 85.69,72.88
PCH_TPD_INT#: length 125.9
  TOP w0.127: v1(85.38,16.31) 86.14,16.31 86.39,16.05 86.39,12.11 v1(86.27,11.99) 86.02,11.74 R360.1 Q19.3
  TOP w0.14: v1(72.12,67) 72.55,67.43 72.93,67.43 73.31,67.06 74.26,67.06 74.83,66.49 76.46,66.49 77.2,67.23 77.49,67.23 R111.2 78.43,66.81 81.41,66.81 81.43,66.83 84.41,66.83 v1(84.84,67.26)
  IN1 w0.089: v1(85.38,16.31) 84.94,16.74 84.94,19.48 83.98,20.44 49.17,20.44 48.37,21.24 48.37,24.88 48.03,25.23 48.03,29.99 55.42,37.38 55.42,40.99 63.96,49.54 63.96,51 65.04,52.07 v1(65.87,52.07)
  IN3 w0.127: v1(72.12,67) 72.12,66.93 72.12,66.93 72.12,66.18 69.12,63.19 69.12,60.01 68.87,59.75 68.87,57.33 68.29,56.75 67.67,56.75 67.66,56.75 67.01,56.75 66.58,56.32 66.58,52.58 66.07,52.07 v1(65.87,52.07)
  BOTTOM w0.089: U22.AC48 88.92,65.05 88.04,65.93 88.04,66.09 87.07,67.06 86.8,67.06 86.72,66.98 86.47,66.98 86.37,67.08 86.19,67.08 86.04,66.93 85.17,66.93 v1(84.84,67.26)
PCH_VDDEN: length 111.8
  TOP w0.127: v1(90.33,92.26) 90.14,92.07 v1(90.14,87.04) 90.14,85.42 90.62,84.94 90.62,83.62 89.69,82.69 89.69,82.16 89.38,81.84 89.38,80.98 90.49,79.87 90.9,79.87 91.52,79.25 91.52,75.46 91.73,75.26 91.73,73.9 v1(91.55,73.72) ; R82.1 155.74,75.09 155.8,75.04 155.8,74.65 155.39,74.24 R620.1 155.08,73.77 152.21,73.77 151.29,74.7 v1(151.29,75.87)
  IN1 w0.089: v1(90.33,92.26) 90.45,92.38 94.1,92.38 95.36,91.12 97.37,91.12 98.89,89.6 108.32,89.6 109.34,90.61 111.79,90.61 114.07,92.89 114.07,94.09 115.14,95.16 v1(115.14,97.08)
  IN3 w0.127: v1(151.29,75.87) 150.96,75.87 149.32,77.5 149.32,79.25 148.51,80.06 143.37,80.06 143.03,80.4 143.03,82.36 142.53,82.87 122.83,82.87 122.08,83.61 122.08,91.26 120.68,92.66 120.68,93.67 119.24,95.11 118.34,95.11 117.64,95.81 116.24,95.81 115.14,96.91 v1(115.14,97.08)
  BOTTOM w0.089: U22.C41 91.92,73.95 91.69,73.72 v1(91.55,73.72)
PCIE_CLK_RCOMP: length 2.1
  TOP w0.152: v1(106.86,70.78) 106.7,70.94 R97.1
  BOTTOM w0.152: U22.L10 105.99,70.35 106.43,70.78 v1(106.86,70.78)
PCIE_CLKREQ0: length 6.9
  BOTTOM w0.089: U22.C45 90.12,74.26 89.94,74.44 89.94,74.45 89.84,74.54 89.84,74.57 89.82,74.6 89.8,74.6 89.78,74.62 89.63,74.62 89.49,74.76 89.49,74.77 89.31,74.94 89.31,76
  BOTTOM w0.127: 89.31,76 87.92,77.39 v1(87.92,79.04) R433.2
PCIE_CLKREQ2_LAN#: length 11.2
  TOP w0.127: v1(88.61,83.95) 88.05,84.5 R41.1
  BOTTOM w0.089: U22.B45 90.12,74.94 89.53,75.52 89.53,76.2 89.23,76.5
  BOTTOM w0.127: R420.2 88.81,81.21 88.55,80.95 88.55,79.55 88.34,79.34 88.34,77.39 88.78,76.95 89.23,76.5
  BOTTOM w0.14: R420.2 88.61,81.92 v1(88.61,83.95)
PCIE_CLKREQ3_WLAN#: length 112.6
  IN1 w0.089: v1(45.5,45.82) 45.72,46.05 45.72,47.9 46.99,49.17 51.26,49.17 54.01,51.91 54.01,53.22 56.89,56.1 56.89,59.25 62.9,65.27 64.52,65.27 68.24,68.99 76.22,68.99 79.59,72.36 79.59,75.74 80.02,76.17 80.02,77.86 82.44,80.29 84.4,80.29 85.93,78.76 85.93,77.17 86.36,76.74 88.09,76.74 88.31,76.52 89.27,76.52 v1(90.08,75.72)
  BOTTOM w0.089: 90.08,76.38 v1(90.08,75.72) 90.08,75.45 90.29,75.23 90.29,74.88 90.4,74.72 90.4,74.59 U22.C44
  BOTTOM w0.127: 90.08,76.38 88.55,77.9 88.55,78.92 89.19,79.55 R434.2 ; v1(45.5,45.82) 46.39,44.93 46.39,44.75 47.4,43.74 v1(47.91,43.74) 47.91,42.34 43.97,38.4 43.97,36.24 43.64,35.91 43.64,28.17 43.09,27.61 43.09,19.56 43.41,19.23 43.41,17.9 42.85,17.34 U33.3 42.85,16.11 42.53,15.8 40.43,15.8 R623.2 39.66,15.03 Q38.3
PCIE_LAN_WAKE#_R: length 21.7
  TOP w0.127: Q1.1 25.2,96.09 v1(26.02,95.27) ; Q1.1 25.46,96.59 25.46,97.25 25.66,97.46 v1(26.32,97.46) R4.1 ; Q1.1 24.75,96.8 24.75,97.38 24.62,97.51 24.04,97.51 23.77,97.77 R2.2 ; U3.21 27.44,89.64 27.36,89.56 v1(27.36,89.56) ; v1(27.34,86.15) 26.96,85.77 R36.1
  IN1 w0.089: v1(26.02,95.27) 26.02,95.27 26.02,91.84 26.7,91.16 26.7,90.15 27.3,89.56 v1(27.36,89.56) 27.36,89.56 27.69,89.56 28.07,89.18 28.07,87.31 28.01,87.25 27.24,87.25 26.94,86.95 26.94,86.55 v1(27.34,86.15)
PCIE_RCOMPN: length 7.3
  BOTTOM w0.089: 108.34,75.69 108.29,75.64 108.29,75.31 108.35,75.25 108.46,75.25 108.51,75.2 108.51,74.76 108.42,74.67 108.1,74.67 108.01,74.57 108.01,74.51 U22.C5
  BOTTOM w0.14: 108.34,75.69 108.34,76.08 108.89,76.63 112.79,76.63 112.94,76.48 R453.2
PCIE_RCOMPP: length 7.3
  BOTTOM w0.089: 108.07,75.72 108.11,75.69 108.11,75.3 107.91,75.1 107.91,74.77 U22.C6
  BOTTOM w0.14: 108.07,75.72 108.07,76.19 108.78,76.9 112.68,76.9 R453.1
PCIE_REQ_LAN#_R: length 81
  TOP w0.127: v1(83.62,84.94) 84.08,85.39 84.64,85.39 85.53,84.5 R41.2 ; R10.2 v1(28.85,94.54) 29.23,94.54 v1(30.38,93.39) 30.84,92.92 U3.12
  IN1 w0.089: v1(28.85,94.54) 33.56,94.54 34.27,93.83 34.27,83.21 v1(33.74,82.68) ; v1(74.84,87.3) 74.84,87.43 75.74,88.33 81.1,88.33 83.34,86.08 83.34,85.22 v1(83.62,84.94)
  BOTTOM w0.127: v1(33.74,82.68) 34.27,83.21 47.63,83.21 51.51,87.08 59.31,87.08 59.78,86.62 68.65,86.62 68.99,86.28 74.58,86.28 74.84,86.54 v1(74.84,87.3)
PCIE_RXN2_LAN: length 127.1
  TOP w0.14: v1(25.31,91.36) 25.31,91.59 25.4,91.68 25.84,91.68 25.93,91.59 C14.2
  IN3 w0.127: v1(107.43,73.37) 107.32,73.27 107.32,73.16 107.43,73.06 107.75,73.06 108.45,72.35 113.96,72.35 114.24,72.64 114.24,74.57 113.51,75.31 113.51,76.75 113.38,76.88 113.38,79.38 114.33,80.33 114.33,84.61 108.29,90.65 100.64,90.65 100.46,90.83 97.95,90.83 97.58,91.2 94.55,91.2 93.34,92.41 91.71,92.41 90.71,91.41 88.96,91.41 88.63,91.74 83.04,91.74 82.38,92.41 72.08,92.41 69.67,90 64.36,90 63.01,88.66 53.69,88.66 47.89,82.85 35.18,82.85 33.12,84.92 33.12,88.12 32.77,88.47 32.77,91.13 32.48,91.43 29.12,91.43 28.91,91.22 28.11,91.22 27.9,91.43 26.84,91.43 26.57,91.69 25.43,91.69 25.31,91.57 v1(25.31,91.36)
  BOTTOM w0.089: v1(107.43,73.37) 107.29,73.23 107.29,73.01 U22.F6
PCIE_RXN2_LAN_C: length 2.5
  TOP w0.14: U3.18 28.04,90.84 27.97,90.9 27.66,90.9 27.08,91.48 26.96,91.48 26.71,91.24 C14.1
PCIE_RXN3_WLAN: length 181.5
  IN3 w0.127: v1(105.86,72.9) 105.99,72.77 106.1,72.77 106.22,72.9 106.22,73.1 106.33,73.22 106.33,73.79 106.86,74.32 108.44,74.32 110.84,76.72 110.84,83.63 109.29,85.18 106.92,87.55 105.47,87.55 104.85,88.16 99.63,88.16 99.48,88.31 99.1,88.31 98.51,87.73 95.07,87.73 94.73,88.07 86.53,88.07 85.66,88.95 78.26,88.95 77.3,89.91 73.06,89.91 70.69,87.54 65.38,87.54 63.88,86.04 59.99,86.04 59.49,85.55 57.71,85.55 57.06,86.19 54.71,86.19 48.91,80.39 36.42,80.39 35.46,79.42 29.71,79.42 27.67,77.39 27.67,67.15 25.79,65.27 25.79,61.66 24.19,60.06 24.19,57.12 22.05,54.99 22.05,48.64 18.7,45.28 18.7,36.69 19.55,35.84 19.55,31.18 21.81,28.92 21.81,27.26 23.15,25.92 23.15,24.67 23.65,24.16 23.65,22.38 29.35,16.69 31.7,16.69 32.1,16.29 32.1,15.63 32.17,15.56 v1(32.52,15.56)
  BOTTOM w0.089: v1(105.86,72.9) 105.91,72.94 106.39,72.94 106.45,72.88 106.45,72.59 106.4,72.54 U22.F9
  BOTTOM w0.14: R591.2 32.22,16.42 32.09,16.29 32.09,15.69 32.22,15.56 v1(32.52,15.56)
PCIE_RXN3_WLAN_NGFF: length 2.8
  BOTTOM w0.14: CN10.43 31.9,18.65 31.78,18.53 31.78,18.23 32.16,17.85 32.16,17.58 R591.1
PCIE_RXP2_LAN: length 127.1
  TOP w0.14: C13.2 25.63,91.95 25.48,91.95 v1(25.31,92.12)
  IN3 w0.127: v1(25.31,92.12) 25.48,91.95 26.67,91.95 26.94,91.68 28,91.68 28.21,91.47 28.8,91.47 29.01,91.68 32.58,91.68 33.03,91.24 33.03,88.57 33.37,88.23 33.37,85.02 35.29,83.11 47.78,83.11 53.59,88.91 62.91,88.91 64.26,90.26 69.56,90.26 71.97,92.67 82.48,92.67 83.15,92 88.73,92 89.06,91.67 90.6,91.67 91.6,92.67 93.44,92.67 94.66,91.45 97.68,91.45 98.05,91.08 100.57,91.08 100.75,90.9 108.39,90.9 114.59,84.71 114.59,80.23 113.63,79.27 113.63,76.99 113.76,76.86 113.76,75.41 114.5,74.68 114.5,74.47 114.5,74.47 114.5,72.53 114.06,72.1 108.35,72.1 107.74,72.71 107.64,72.8 107.33,72.8 107.3,72.84 v1(106.85,72.84)
  BOTTOM w0.089: v1(106.85,72.84) U22.E7
PCIE_RXP2_LAN_C: length 2.5
  TOP w0.14: C13.1 26.71,92 26.96,91.75 27.2,91.75 27.77,91.17 27.97,91.17 28.04,91.24 U3.17
PCIE_RXP3_WLAN: length 181.5
  IN3 w0.127: v1(31.66,15.56) 31.85,15.76 31.85,16.18 31.6,16.43 29.24,16.43 23.4,22.27 23.4,24.05 22.89,24.56 22.89,25.82 21.56,27.15 21.56,28.81 19.3,31.08 19.3,35.73 18.45,36.58 18.45,45.39 21.8,48.74 21.8,55.09 23.93,57.23 23.93,60.17 25.53,61.77 25.53,65.38 27.41,67.26 27.41,77.49 29.6,79.68 35.35,79.68 36.32,80.64 48.8,80.64 54.61,86.45 57.17,86.45 57.81,85.8 59.39,85.8 59.88,86.29 63.78,86.29 65.28,87.79 70.58,87.79 72.96,90.17 77.4,90.17 78.37,89.2 85.76,89.2 86.64,88.33 94.84,88.33 95.18,87.98 98.41,87.98 98.99,88.57 99.58,88.57 99.74,88.42 104.96,88.42 105.58,87.8 107.03,87.8 109.9,84.93 111.09,83.73 111.09,76.62 108.54,74.06 106.97,74.06 106.59,73.68 106.59,73.16 106.43,73.01 106.43,72.76 v1(105.86,72.19)
  BOTTOM w0.089: U22.H9 106.22,71.83 v1(105.86,72.19)
  BOTTOM w0.14: R590.2 31.82,16.13 31.82,15.73 v1(31.66,15.56)
PCIE_RXP3_WLAN_NGFF: length 2.8
  BOTTOM w0.14: CN10.41 31.4,18.65 31.52,18.53 31.52,18.12 31.9,17.74 31.9,17.57 R590.1
PCIE_TXN2_LAN: length 119.3
  TOP w0.14: U3.14 30.04,92.73 29,93.77 26.84,93.77 26.46,94.15 25.53,94.15 v1(25.29,93.9)
  IN3 w0.127: v1(112.92,82.78) 112.92,82.58 113.05,82.45 113.27,82.45 113.42,82.6 113.42,84.27 107.72,89.97 100.33,89.97 100.15,90.14 97.66,90.14 97.29,90.51 95.04,90.51 94.87,90.35 88.39,90.35 87.68,91.06 82.76,91.06 82.12,91.69 72.33,91.69 69.95,89.32 64.65,89.32 63.3,87.97 53.97,87.97 48.17,82.17 34.9,82.17 31.99,85.08 31.99,86.87 31.17,87.68 28.83,87.68 27.83,88.68 27.83,90.31 27.51,90.64 26.94,90.64 26.28,89.98 25.02,89.98 24.61,90.39 24.61,92.49 24.94,92.82 25.6,92.82 25.84,93.06 25.84,94 25.65,94.19 25.41,94.19 25.29,94.06 v1(25.29,93.9)
  BOTTOM w0.14: v1(112.92,82.78) 112.92,82.57 112.81,82.46 112.03,82.46 111.43,81.86 111.43,81.16 111.36,81.08 C368.1
PCIE_TXN2_LAN_C: length 9.2
  BOTTOM w0.089: 106.87,75.72 106.87,75.7 106.9,75.67 106.9,75.37 106.8,75.27 106.45,75.27 106.36,75.18 106.36,75.04 106.57,74.84 106.57,74.68 106.5,74.61 106.39,74.61 U22.B9
  BOTTOM w0.14: 106.87,75.72 106.87,76.03 108.78,77.94 109.62,77.94 111.4,79.72 111.4,80.21 111.31,80.3 C368.2
PCIE_TXN3_WLAN: length 178.8
  IN3 w0.127: v1(109,81.84) 109.25,82.09 109.25,84.12 106.51,86.86 105.33,86.86 104.85,86.37 91.64,86.37 91.01,86.99 89.67,86.99 89.21,86.54 86.06,86.54 84.49,88.11 77.32,88.11 76.21,89.23 73.35,89.23 70.97,86.85 65.67,86.85 64.17,85.35 60.27,85.35 59.78,84.86 54.67,84.86 51.02,81.21 50.7,81.21 49.19,79.7 36.71,79.7 35.74,78.74 29.99,78.74 28.35,77.1 28.35,66.85 26.47,64.97 26.47,61.38 24.87,59.78 24.87,56.82 22.74,54.68 22.74,48.35 19.46,45.07 19.46,38.13 20.24,37.35 20.24,31.47 22.5,29.2 22.5,27.54 23.83,26.21 23.83,25.64 23.83,25.38 25.18,24.03 25.18,22.76 24.92,22.5 24.92,22.13 29.68,17.37 32.59,17.37 33.83,16.14 33.83,15.43 32.8,14.4 30.24,14.4 27.72,11.89 27.72,11.57 v1(27.98,11.32)
  BOTTOM w0.14: v1(27.98,11.32) 27.73,11.57 27.73,12.13 29.64,14.03 29.64,14.64 29.77,14.77 R598.2 ; v1(109,81.84) 109.42,81.42 109.42,81.21 109.29,81.08 C366.2
PCIE_TXN3_WLAN_C: length 7.6
  BOTTOM w0.089: U22.A10 105.76,74.97 105.69,75.04 105.69,75.16 105.77,75.24 105.9,75.24 105.97,75.31 105.97,75.47 106.14,75.64 106.14,75.8 106.09,75.85 106.09,75.87
  BOTTOM w0.14: C366.1 109.28,80.3 109.38,80.21 109.38,79.72 106.09,76.44 106.09,75.87
PCIE_TXN3_WLAN_NGFF: length 4.9
  BOTTOM w0.14: R598.1 29.79,15.89 29.79,16.29 v1(30.31,16.81) 29.79,17.33 29.79,17.59 30.28,18.09 30.28,18.53 30.4,18.65 CN10.37
PCIE_TXP2_LAN: length 119.3
  TOP w0.14: U3.13 30.44,92.7 29.11,94.04 26.95,94.04 26.57,94.42 25.53,94.42 v1(25.29,94.66)
  IN3 w0.127: v1(112.92,82.02) 113.09,82.19 113.38,82.19 113.68,82.49 113.68,84.37 107.83,90.22 100.44,90.22 100.26,90.4 97.77,90.4 97.4,90.77 94.93,90.77 94.77,90.6 88.49,90.6 87.78,91.31 82.87,91.31 82.23,91.95 72.22,91.95 69.85,89.57 64.54,89.57 63.19,88.23 53.87,88.23 53.86,88.21 48.07,82.42 35,82.42 32.24,85.18 32.24,86.97 31.28,87.93 28.94,87.93 28.09,88.78 28.09,90.42 27.61,90.89 26.84,90.89 26.18,90.23 25.12,90.23 24.86,90.49 24.86,92.39 25.04,92.57 25.7,92.57 26.09,92.96 26.09,94.11 25.76,94.44 25.51,94.44 v1(25.29,94.66)
  BOTTOM w0.14: C369.1 111.7,81.3 111.7,81.75 112.14,82.19 112.74,82.19 v1(112.92,82.02)
