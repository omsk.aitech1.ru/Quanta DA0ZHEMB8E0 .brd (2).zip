# Allegro board Quanta ZHE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N30371961: length 1.1
  TOP w0.127: R290.1 42.96,32.94 TP33.1
N30372639: length 2.4
  TOP w0.127: R296.2 21.14,31.04 v1(21.29,31.19) 21.68,31.58 21.92,31.58
  TOP w0.14: U14.18 21.92,31.58
N30372887: length 3.1
  TOP w0.127: R292.1 41.82,32.31 42.83,32.31 42.96,32.18 TP34.1
N30372945: length 3
  TOP w0.127: v1(19.72,33.96) 19.84,34.08 C231.1 20.7,33.98 U14.12
N30377243: length 2.9
  TOP w0.127: R289.1 18.95,33.96 v1(18.32,33.96) 18.32,33.33 C233.2
N30404052: length 2.4
  BOTTOM w0.127: PR170.2 v1(132.87,66.6)
  BOTTOM w0.508: PC161.1 133.93,67.65 PR170.2
N30404082: length 15.8
  TOP w0.254: v1(123.15,73.02) 123.15,73.46 v1(123.63,73.94) 124.62,74.93 134.32,74.93 134.53,74.73 136.43,74.73 v1(136.81,75.11)
  BOTTOM w0.254: PR144.1 136.94,74.98 v1(136.81,75.11)
N30404100:
  vias: v1(137.95,67.87)
N30413525: length 3.1
  TOP w0.508: PR79.2 114.32,35.85 v1(114.59,36.12) 114.71,36.24 PQ9.3
N30417403: length 27.9
  TOP w0.508: PR94.1 145.62,15.76 v1(145.02,15.16)
  IN1 w0.508: v1(123.56,15.03) 123.56,13.81 123.95,13.42 133.44,13.42 134.58,14.55 144.41,14.55 v1(145.02,15.16)
  BOTTOM w0.127: PR257.1 121.96,17.44 121.35,16.83 121.35,15.34 121.67,15.02 PR259.1
  vias: v1(122.91,17.57) v1(122.91,16.93) v1(122.91,16.3) v1(122.91,15.66) v1(122.91,15.03) v1(123.56,17.57) v1(123.56,16.93) v1(123.56,16.3) v1(123.56,15.66)
N30417483: length 2.5
  TOP w0.127: v1(134.69,16.94) PC74.1
  TOP w0.508: PC74.1 PR86.2
N30417620: length 4.5
  TOP w0.178: PU2.10 147.11,10.44 PR107.1 147.72,9.58 147.99,9.32 149.38,9.32 149.76,9.69 PR108.2
N30417647: length 4.5
  TOP w0.508: PQ13.4 124.23,13.38 124.11,13.5 PC85.2 122.12,13.5 PR96.2 120.72,13.8 v1(120.56,13.64)
N30417687: length 8.2
  TOP w0.508: PC27.2 17.09,71.4 PR15.1 PC22.2 18.18,71.05 18.57,70.66 v1(19.67,70.66) v1(21.22,69.11)
  BOTTOM w0.508: v1(21.22,69.11) 21.7,69.59 PQ17.4
N30417707: length 1.6
  TOP w0.178: PR122.1 144.58,7.4 PU2.5
N30417720: length 1.5
  TOP w0.178: PU2.11 PR106.1
N30417725: length 4.1
  TOP w0.127: PR105.1 147.72,12.11 147.99,12.37 149.51,12.37 v1(149.64,12.5)
  TOP w0.178: PU2.12 147.11,11.24 PR105.1
N30417727: length 3.8
  TOP w0.127: v1(147.61,6.4) 147.23,6.78 147.23,7.03 146.96,7.3 PR124.1
  TOP w0.178: PR124.1 146.22,7.8 145.7,7.8 145.38,8.12 PU2.7
N30417731: length 2.1
  TOP w0.178: PU2.9 146.63,10.04 147.35,9.32 147.35,9.18 PR110.1
N30417774: length 5.7
  TOP w0.127: v1(149.89,14.91) 149.88,14.9 PR91.1
  TOP w0.178: PR91.1 PR90.1 147.9,14.9 146.62,13.61 145.65,13.61 145.38,13.34 PU2.15
N30417841: length 2.5
  TOP w0.178: PR112.1 v1(146.84,8.68) 146.18,9.34 PU2.8
N30418865: length 2
  TOP w0.178: PU2.20 143.38,13.42 142.63,14.17 PR92.2
N30418874: length 2
  TOP w0.178: PR93.2 143.67,14 143.67,13.51 143.78,13.4 PU2.19
N30418916: length 2.5
  BOTTOM w0.127: PR261.1 97.43,14.26 v1(97.35,14.18) PJ16.5
N30431765: length 3.7
  TOP w0.127: PU4.4 PC93.1 155.1,11.47 155.1,12.49 155.6,12.99 PR99.1
N30431769: length 1.2
  TOP w0.178: PC108.1 156.01,6.52 PU4.12
N30431771: length 1.2
  TOP w0.178: PU4.10 155.21,6.52 PC107.1
N30431804: length 4
  TOP w0.127: PR98.2 154.59,12.99 154.13,12.54 154.13,11.42 PC92.1 154.78,10.96 155.21,10.53 PU4.5
N30431812: length 4.1
  TOP w0.127: PR100.1 156.62,12.99 156.12,12.49 156.12,11.47 PC94.1 156.31,10.96 156.01,10.66 PU4.3
N30574961: length 7.5
  TOP w0.127: LED1.4 72.54,91.48 v1(72.68,91.62) 71.72,92.57 71.72,93.66 71.29,94.1 EC2.2 70.78,94.16 70.02,94.16 R9.2
N30574965: length 5.8
  TOP w0.127: R14.2 70.02,93.9 70.78,93.9 EC3.2 71.34,93.34 v1(71.34,91.62) 71.64,91.31 LED1.3
N30574981: length 8.5
  TOP w0.127: LED2.4 83.87,89.35 83.74,89.21 82.53,89.21 v1(81.86,89.88) 81.73,90.01 81.73,91.16 EC4.2 R15.2
N30574985: length 17.8
  TOP w0.127: LED2.3 82.97,91.4 v1(82.54,91.83) 80.57,93.8 76.99,93.8 76.74,93.55 74.47,93.55 72.42,95.6 72.42,96.7 71.8,97.32 R3.2 EC1.2
N30575269: length 3.6
  TOP w0.127: U11.24 163.63,45.75 163.1,46.28 162.21,46.28 v1(161.83,46.66) 161.45,46.28 C203.2
N30954436:
  vias: v1(161.07,49.71)
N30954444: length 2.9
  BOTTOM w0.508: PU12.7 161.2,53.38 160.95,53.14 PR223.1 160.95,51.37 PR224.2
N31161958: length 3.9
  BOTTOM w0.127: PR180.2 157,66.21 156.81,66.03 155.53,66.03 PC174.1 PU9.4
N31161974: length 1.6
  TOP w0.127: PC36.1 151.04,67.23 v1(150.78,66.98)
  BOTTOM w0.127: PU9.12 150.8,67 v1(150.78,66.98)
N31161976: length 1.6
  TOP w0.127: PC38.1 150.91,66.22 v1(150.78,66.34)
  BOTTOM w0.127: v1(150.78,66.34) 150.93,66.2 PU9.10
N31162017: length 4
  BOTTOM w0.127: PR184.1 157,65.58 156.55,65.14 155.48,65.14 155.04,65.58 PC179.1 154.96,65.87 154.64,66.2 PU9.5
N31162025: length 4.9
  BOTTOM w0.127: PU9.3 154.58,67 154.96,67.38 PC164.1 155.41,68.06 157.58,68.06 157.77,67.86 PR174.2
N31255598: length 18.5
  TOP w0.127: v1(185.58,13) 185.58,12.25 HE1.2 ; v1(173.26,11.48) 172.75,11.99 C312.1 D28.2 R370.1
  BOTTOM w0.127: v1(173.26,11.48) 174.02,12.24 183.04,12.24 183.29,12.5 185.07,12.5 v1(185.58,13)
N31257808: length 3.1
  TOP w0.127: U17.7 95.54,10.34 v1(95.79,10.08) 95.54,9.83 R377.2
N31411910: length 21.1
  TOP w0.127: R276.1 44.62,40.05 46.56,40.05 46.84,40.33 46.84,41.45 46.17,42.12 46.17,43.81 U12.3 46.51,44.16 46.51,45.62 45.78,46.35 45.32,46.35 44.82,45.86 43.04,45.86 43.04,45.85 v1(41.94,44.75) 41.46,44.27 37.65,44.27 37.37,43.99 37.37,42.67 36.62,41.92 R271.1
N31539110: length 17.9
  TOP w0.14: R325.1 16.8,19.73 16.76,19.69 D24.1 16.16,19.23 17.14,18.25 17.14,12.96 12.1,7.92 v1(12.1,7.8)
  BOTTOM w0.14: v1(12.1,7.8) 12.1,8.69 12.4,8.99 CN16.27
N31585508: length 2.1
  TOP w0.254: v1(47.86,53.2) 48.05,53.39 R187.2
  BOTTOM w0.254: v1(47.86,53.2) 47.83,53.22 CN7.11
N31585541: length 3.1
  TOP w0.127: v1(47.15,50.85) 47.18,50.88 v1(47.9,50.88)
  TOP w0.254: v1(47.9,50.88) 47.92,50.88 48.27,51.23 R201.2
  BOTTOM w0.254: CN7.15 47.41,51.22 47.76,50.88 v1(47.9,50.88)
N31585543: length 2.9
  TOP w0.127: v1(47.91,52.22) 47.25,52.22 v1(47.15,52.12)
  TOP w0.254: v1(47.91,52.22) 47.93,52.25 R194.2
  BOTTOM w0.254: CN7.13 v1(47.91,52.22)
N31585594: length 3.4
  BOTTOM w0.14: R513.2 45.38,59.23 v1(45.88,59.23) 45.88,58.72 45.75,58.6 45.75,58.11 46.14,57.72 CN7.2
N31585612: length 2.5
  BOTTOM w0.14: CN7.5 v1(45.16,56.22) 44.99,56.39 R521.2
N31585632: length 2.3
  TOP w0.254: v1(47.83,54.74) 48.46,54.74 R180.2
  BOTTOM w0.254: v1(47.83,54.74) 47.83,54.61 47.45,54.22 CN7.9
N31670929: length 71.9
  TOP w0.127: v1(63.86,14.11) 63.86,12.57 62.89,11.6 62.89,11.09 v1(62.39,10.59) 62.39,9.7 62.14,9.45 Q24.3
  IN3 w0.127: v1(117.72,19.2) 117.72,18.94 117.06,18.27 112.25,18.27 110.86,16.88 86.96,16.88 85.82,18.02 74.52,18.02 70.21,13.7 64.26,13.7 v1(63.86,14.11)
  BOTTOM w0.127: SW2.4 SW2.3 118.85,20.33 v1(117.72,19.2)
N31709164: length 3.7
  TOP w0.102: v1(26.4,95.81) 26.53,95.67 R6.2
  TOP w0.127: R7.2 28.2,95.43 27.95,95.18 27.47,95.18 27.2,94.91 R10.1
  TOP w0.14: R6.2 R7.2
N32197751: length 4.9
  BOTTOM w0.127: R583.1 16.79,19.22 17.39,19.82 Q35.3 18.08,19.82 v1(18.68,19.23) 18.68,20.12 18.32,20.47 Q35.2
N32197909: length 21.6
  BOTTOM w0.127: v1(21.24,29.16) 21.47,29.39 U31.1 23.27,29.39 23.78,29.89 25.23,29.89 26.99,28.13 26.99,26.13 25.98,25.12 23.96,25.12 22.26,23.42 19.99,23.42 18.78,22.21 18.38,22.21 17.91,21.74 17.2,21.74 16.57,21.12 Q35.6
N32459164:
  vias: v1(150.45,23.67)
N32459172: length 3.5
  BOTTOM w0.127: v1(143.16,22.1) 143.16,21.52 PR253.2
  BOTTOM w0.203: PC226.1 144.41,21.76 PU15.4
  BOTTOM w0.254: PC226.1 PR253.2
N32459174: length 21.8
  IN1 w0.254: v1(146.17,31.67) 146.17,31.14 145.32,30.29 144.87,30.29 140.06,25.47 137.93,25.47 v1(137.45,25.96)
  BOTTOM w0.254: v1(146.17,31.67) 146.17,31.66 146.76,31.06 148.77,31.06 150.15,32.44 150.15,33.93 150.53,34.31 152.13,34.31 152.57,33.87 PC214.1 ; PR243.1 v1(137.45,25.96)
  vias: v1(153.19,33.58) v1(153.19,32.94)
N32459193: length 10.3
  TOP w0.254: v1(139.42,22.28) 140.79,22.28 144.1,18.96 PC68.1
  BOTTOM w0.254: PR252.1 139.72,22.28 v1(139.42,22.28)
  vias: v1(147.48,17.96) v2(148.5,17.58) v2(149.51,17.58) v2(150.65,17.58) v2(151.42,17.58)
N32459334: length 1.4
  BOTTOM w0.203: PU15.3 144.81,21.39 PR254.1
N32459384: length 2.6
  TOP w0.127: v1(152.31,29.13) PC66.1
  TOP w0.508: PC66.1 PR85.2
N33096788: length 2.6
  BOTTOM w0.127: v1(43.21,13) 43.2,13.01 R617.1 42.32,13.89 42.2,14.02 U33.5
N33973281: length 1.3
  BOTTOM w0.127: PU5.1 108.99,83.39 PR133.1
N33973285: length 10.4
  BOTTOM w0.127: PC119.1 112.54,86.41 113.59,86.41 PR131.2 113.71,86.17 113.19,85.65 113.19,85.36 112.95,85.12 110.89,85.12 110.52,84.76 110.52,84 111.03,83.49 112.08,83.49 PU5.5 112.34,83.62 113.64,83.62 v1(113.76,83.49)
N33973296: length 2.7
  BOTTOM w0.127: v1(107.98,85.65) 108.05,85.58 PU5.3 109.62,85.93 PR130.2
N33998046:
  vias: v2(38.64,70.19)
N33998081: length 3.1
  TOP w0.203: PU1.13 32.98,68.25 32.85,68.37 32.17,68.37 v1(32.07,68.27)
  TOP w0.508: PC33.1 31.97,68.38 v1(32.07,68.27)
  BOTTOM w0.508: v1(32.07,68.27) 32.05,68.25 PR168.2
N33998093: length 10.1
  TOP w0.203: PC44.1 30.41,61.81 v1(30.41,61.51) 30.41,61.12 PR60.1 ; PR54.1 v1(33.81,60.25)
  IN2 w0.203: v1(30.41,61.51) 31.19,60.73 33.33,60.73 v1(33.81,60.25)
  BOTTOM w0.203: PC195.1 PR219.2 34.3,59.32 34.3,59.95 34,60.25 v1(33.81,60.25) ; v1(30.41,61.51) 30.41,61.12 PR60.1 PC191.2
N33998109: length 2.2
  TOP w0.203: PR30.2 26.96,65.96 v1(26.45,65.45) 27.08,64.82 PC41.1
N33998124: length 45.2
  TOP w0.254: v1(28.86,62.53) PR47.2 28.11,62.29 27.33,61.51 PR51.1
  IN1 w0.178: v1(43.59,77.27) 43.59,77.57 42.79,78.37 24.05,78.37 23.29,77.61 23.29,69.99 24.67,68.6 26.84,68.6 27.97,67.47 27.97,63.24 28.68,62.53 v1(28.86,62.53)
  BOTTOM w0.127: v1(28.99,61.34) 28.86,61.47 v1(28.86,62.53)
  BOTTOM w0.178: PR134.1 43.59,78.78 v1(43.59,77.27)
N33998244: length 2.7
  TOP w0.203: PU1.3 36.75,65.15 v1(36.9,64.99)
  BOTTOM w0.203: PR191.1 37.16,64.06 v1(36.9,64.31) v1(36.9,64.99)
N33998269: length 35.9
  TOP w0.178: v1(42.32,77.27) 41.94,76.88 PR10.1
  TOP w0.203: v1(25.62,69.34) 25.62,68.08 25.94,67.77 25.94,64.69 v1(26.51,64.12) 26.96,63.68 PR41.1
  IN1 w0.178: v1(25.62,69.34) 25.6,69.31 24.75,69.31 23.88,70.19 23.88,76.5 23.88,77.42 24.28,77.81 42.09,77.81 42.32,77.57 v1(42.32,77.27)
N33998478: length 1.8
  TOP w0.203: PU1.25 33.78,61.69 PR54.2
N33998484: length 1.3
  TOP w0.203: PR57.1 37.23,60.86 PR65.2
N33998495: length 2.4
  BOTTOM w0.127: PR212.2 36.1,60.12 v1(36.23,59.99)
  BOTTOM w0.203: PR213.1 36.46,60.87 PR212.2
N33998499: length 1.3
  TOP w0.203: PR56.1 PR67.2
N33998510: length 3.7
  BOTTOM w0.127: v1(34.96,59.99) PR211.2 34.45,61.38 34.45,61.9 34.96,62.41 PR197.1
N33998512: length 2.1
  TOP w0.127: PR66.2 v1(34.08,59.62)
  TOP w0.203: PR55.1 PR66.2
N33998523: length 3.2
  BOTTOM w0.203: PR210.2 33.31,61.38 33.31,62.15 v1(32.93,62.53) 33.36,62.97 33.5,62.97 PR196.1
N33998541: length 1.1
  TOP w0.203: PR36.1 PR31.2
N33998543: length 2.2
  TOP w0.203: PR36.2 30.01,65.17 30.39,65.55 PU1.18
N33999614: length 18.7
  TOP w0.178: v1(30.64,67.64) 30.57,67.64 v1(29.41,68.8) 29.03,69.18 28.73,69.18 28.52,69.38 28.11,69.38
  TOP w0.203: PR21.1 PR24.1 29.23,67.12 PR28.2
  IN2 w0.178: v1(39.91,71.17) 39.91,70.05 39.71,69.85 39.35,69.85 39.02,69.52 37.09,69.52 35.11,67.54 32.29,67.54 32.07,67.31 31.07,67.31 30.74,67.64 v1(30.64,67.64)
  BOTTOM w0.254: PR159.2 v1(39.91,71.17)
N33999624: length 2.2
  TOP w0.127: PR16.1 v1(28.99,70.41)
  TOP w0.178: PR16.1 28.11,70.29 27.33,69.51 PR21.2
N33999632: length 2.5
  TOP w0.127: v1(26.45,68.5) 27.07,68.5 PR24.2
  TOP w0.203: PR27.1 28.11,67.47 PR24.2
N34019717: length 4.3
  TOP w0.127: v1(54.45,62.66) 54.07,63.04 v1(53.75,63.04) 53.44,62.73 53.44,62.36 PR63.2
  BOTTOM w0.127: PU10.25 54.31,62.8 v1(54.45,62.66)
N34019719: length 10.3
  TOP w0.127: PR63.1 52.86,60.45 v1(53.47,59.84) 53.81,60.18 54.6,60.18 55.02,60.6 PC46.1 55.79,61.38 PR58.2
  BOTTOM w0.127: v1(53.47,59.84) 53.81,60.18 55.1,60.18 PC194.2 55.57,59.77 55.57,60.32 PR214.2 PC189.1
N34019737: length 2
  BOTTOM w0.127: PR198.1 49.05,63.04 v1(48.55,63.04) 47.78,63.04 PR201.1
N34019748: length 2.1
  TOP w0.127: PR45.2 48.94,63.42 PR46.1 48.43,62.14 v1(48.37,62.08)
N34019771: length 1.3
  BOTTOM w0.127: PR199.1 51.2,62.8 PR207.2
N34019785: length 2.3
  TOP w0.127: PR48.2 50.21,61.63 PR52.1 50.45,61.14 v1(50.45,60.55)
N34019789: length 2.3
  BOTTOM w0.127: PR200.1 52.98,62.8 PR208.2 53.76,61.48 v1(54.06,61.19)
N34019800: length 1.2
  TOP w0.127: PR62.1 51.34,60.51 PR50.2
N34020717: length 1.2
  BOTTOM w0.127: PR176.1 59.34,67.48 PR172.2
N34020735: length 4.3
  BOTTOM w0.127: PR176.2 59.93,66.79 59.02,66.79 58.88,66.93 v1(57.64,66.93) 57.44,66.93 57.08,66.56 PU10.18
N34020901: length 13.8
  BOTTOM w0.178: PR182.1 62.05,65.93 62.64,65.93 63.93,67.23 64.49,67.23 64.93,67.67 64.93,71.5 65.95,72.52 65.95,75.74 65.32,76.37 PR140.2
N34021029: length 7.8
  TOP w0.508: v1(55.79,69.9) 57.69,69.9 v1(58.07,70.28) 58.61,70.82 PR14.2
  BOTTOM w0.203: PU10.13 55.11,69.2 55.3,69.39 55.71,69.39 55.96,69.14 56.3,69.14 PC155.1
  BOTTOM w0.254: v1(55.79,69.9) 55.96,69.9 56.19,69.67 56.26,69.67 PC155.1
N34021054: length 8.4
  BOTTOM w0.127: v1(63.66,67.74) 62.69,66.77 61.7,66.77 61.49,66.99 PR177.1 60.8,66.54 57.88,66.54 57.82,66.47 57.35,66.47 57.04,66.16 PU10.19
N34021115: length 1.8
  BOTTOM w0.127: PC160.1 61.4,68.25 v1(61.2,68.04) 60.99,68.25 PR169.2
N34021177: length 22.4
  IN3 w0.178: v1(57.56,65.45) 57.69,65.58 60.61,65.58 60.99,65.2 v1(60.99,65.07)
  BOTTOM w0.178: PR136.1 67.22,76.98 66.55,76.31 66.55,72.26 65.54,71.25 65.54,67.41 64.74,66.62 64.19,66.62 62.86,65.29 61.21,65.29 v1(60.99,65.07) ; v1(57.56,65.45) 57.7,65.32 PR183.2 PR194.1
N34021183: length 4.1
  BOTTOM w0.127: PR154.1 60.46,70.41 v1(60.41,70.46) 60.11,70.16 PR161.1 PR157.2 PR160.2
N34021195: length 2.4
  BOTTOM w0.127: PR154.2 v1(63.53,70.41) 63.53,69.78 PR155.1
N34021205: length 2
  BOTTOM w0.127: PR161.2 60.5,69.38 60.67,69.21 v1(60.69,69.21) 60.87,69.39 PR162.1
N34345368: length 2.5
  TOP w0.127: R163.1 v1(62.24,58.08)
  BOTTOM w0.127: U26.A7 62.39,57.93 v1(62.24,58.08)
N34396238: length 5.7
  TOP w0.127: U10.5 21.75,44.88 21.62,44.75 20.73,44.75 20.6,44.62 R269.1 20.6,41.18 v1(20.66,41.12)
N34463015: length 12.6
  TOP w0.508: PR17.2 174.94,70.02 174.94,69.66 174.56,69.29 173.76,69.29 PR20.1 173.51,68.12 v1(173.13,67.74) 170.69,65.3 169.22,65.3 168.92,65 PQ3.2 168.59,63.96 PQ4.3
N34463017: length 3
  TOP w0.508: PQ3.3 170.31,66.32 v1(171.1,67.11) 171.74,67.74 PR22.2
N34463075: length 8
  TOP w0.127: PQ4.2 166.57,66.64 165.48,66.64 165.37,66.52 165.37,65.87 165.17,65.67 163.95,65.67 163.35,65.07 PR35.1 162.36,65.07 v1(161.71,65.72) PR37.2
N34466148: length 6.4
  BOTTOM w0.127: PR189.1 46.71,64.44 47.5,65.23 48.2,65.23 v1(48.42,65.45) 49.18,66.21 51.59,66.21 51.63,66.16 PU10.3
N34516046: length 3.4
  BOTTOM w0.127: TP61.1 16.5,22.45 R573.1 16.66,22.44 17.08,22.02 17.1,22 17.81,22 18.45,22.64 R572.1
N34640237: length 6
  BOTTOM w0.127: CN15.20 47.35,6.39 46.7,7.03 44.23,7.03 v1(43.72,7.54) 43.07,8.19 R604.1
N34664651: length 13.6
  TOP w0.127: R336.1 105.5,15.38 106.08,14.81 106.08,9.83 105.82,9.57 105.19,9.57 104.3,8.69 103.28,9.7 103.28,10.34 v1(102.65,10.97) 101.76,10.97 Q21.3
N34725490: length 9.2
  TOP w0.127: Q27.3 119.06,9.29 119.54,8.81 119.54,8 Q25.2 121.14,8.43 122.21,8.43 v1(123.22,9.45) 123.61,9.45 R372.2
N34728734: length 11.8
  BOTTOM w0.127: CN15.8 53.35,6.75 53.12,6.98 53.12,12.37 53.5,12.75 54.52,12.75 55.91,14.15 v1(56.42,14.15) R606.1
N34749031: length 10.7
  TOP w0.127: R182.2 114.2,53.64 v1(113.95,53.64) 112.12,53.64 v1(111.33,52.85)
  IN1 w0.089: v1(111.33,52.85) 111.33,52.95 110.87,53.41 110.45,53.41 110.23,53.19 109.51,53.19 107.18,55.52 v1(106.81,55.52)
  BOTTOM w0.089: v1(106.81,55.52) U22.BC8
N34841935: length 3.6
  TOP w0.127: R54.2 170.56,79.3 170.35,79.09 v1(170.03,79.09)
  TOP w0.508: R54.2 170.21,80.4 v1(170.21,80.95)
  BOTTOM w0.254: CN5.4 169.98,80.63 170.21,80.86 v1(170.21,80.95)
N34843450: length 4.9
  BOTTOM w0.127: R448.2 168.3,78.03 v1(167.8,78.03) 167.8,78.79 167.6,78.99 165.82,78.99 165.48,79.33 CN5.13
N34855062: length 29.6
  TOP w0.381: R212.2 v1(114.46,48.29) 107.66,48.29 v1(107.07,47.7)
  IN3 w0.254: 102.44,55.94 102.44,56.21 101.5,57.14 101.5,58.44 99.72,60.22 98.71,60.22 98.26,59.77 98.26,59.26 97.7,58.69 v1(96.78,58.69)
  IN3 w0.381: v1(107.07,47.7) 107.07,48.51 106.76,48.82 105.77,48.82 103.41,51.18 103.41,53.11 102.44,54.08 102.44,55.94
  BOTTOM w0.254: v1(96.78,58.69) 96.96,58.69 97.26,58.4 U22.AV29
N34966351: length 4.5
  TOP w0.127: PC57.2 PR74.2 155.62,46.66 PR75.1 155.35,46.67 v1(154.72,47.3)
  BOTTOM w0.127: PU13.12 155.26,47.66 154.9,47.3 v1(154.72,47.3)
N34966402: length 1.9
  TOP w0.127: PC57.1 157.52,44.62 v1(157.64,44.5) PR76.1
N34966644: length 3.5
  BOTTOM w0.203: PR237.1 165.48,31.39 PU14.9
  BOTTOM w0.254: PR236.2 PC217.2 166.4,31.55 PR237.1
N34966684: length 1.1
  BOTTOM w0.254: PC217.1 167.29,31.66 167.29,30.92 PR238.1
N34966797: length 4.7
  TOP w0.254: PR80.2 PC65.1 166.62,31.13 v1(165.26,29.77)
  BOTTOM w0.203: PU14.12 164.99,30.04 v1(165.26,29.77)
N34967490: length 5.6
  BOTTOM w0.127: PR231.2 151.46,42.17 v1(151.46,42.47) PR229.1 151.46,43.53 151.67,43.74 151.67,44.12 151.46,44.32 PR227.1 151.58,44.5 152.09,45.01 152.56,45.01 153.07,44.5 PR228.2
N34971076: length 7.4
  TOP w0.508: PR69.2 160.57,56.06 160.31,56.31 PC51.1 160.31,56.95 v1(161.07,57.71) 161.32,57.96 161.32,58.85 161.97,59.49 PR64.1 163.36,61.14 PQ6.1
N34971086: length 17.9
  TOP w0.508: PQ6.3 162.62,63.3 v1(163.86,63.3) 164.75,63.3 v1(165.13,63.68)
  IN2 w0.508: v1(172.5,72.57) 170.58,70.65 170.58,67.74 166.52,63.68 v1(165.13,63.68)
  BOTTOM w0.508: R499.1 v1(165.13,63.68)
N34971104: length 5.1
  TOP w0.508: PC51.2 159.54,56.95 PR68.1 159.78,58.33 v1(160.43,58.98) PR64.2 161.21,59.76 161.21,60.11 161.47,60.37 PQ6.2
N34971124: length 6.8
  TOP w0.381: PQ5.3 159.06,62.89 160.15,62.89 v1(160.56,63.3) 160.64,63.22 160.64,60.13 160.63,60.12 160.63,59.99 159.75,59.11 PR68.2
N34971155: length 4.4
  TOP w0.127: PR34.2 157.77,64.07 v1(157.77,63.55) PQ5.2
N35023087: length 2.1
  TOP w0.127: R66.2 116.01,80.47 v1(116.01,81.15) 116.01,81.48 116.45,81.92 U6.36
N35182776: length 5.1
  BOTTOM w0.127: v1(124.88,21.01) R575.1 126.39,21.51 126.55,21.51 127.31,22.27 127.77,22.27 128.18,21.87 128.81,21.87 128.95,22.01 U32.10
N35212197: length 3.4
  TOP w0.127: TP10.1 101.63,70.33 101.63,72.41 v1(102.11,72.9)
  BOTTOM w0.089: v1(102.11,72.9) 102.05,72.9 U22.F19
N35212200: length 1.2
  TOP w0.127: TP5.1 103.05,72.87 v1(103,72.82)
  BOTTOM w0.089: U22.F17 102.85,72.82 v1(103,72.82)
N35276950: length 3.2
  TOP w0.127: PQ8.3 159.9,52.78 v1(160.31,52.37)
  TOP w0.508: PR70.2 161.8,53.47 PQ8.3
N35413235: length 28.7
  TOP w0.127: v1(72.76,67.01) 72.8,66.96 TP62.1
  IN3 w0.127: v1(92.49,72.21) 92.01,72.69 92.01,73.01 91.75,73.27 91.05,73.27 90.93,73.38 86.24,73.38 85,74.62 82.89,74.62 81.77,75.74 80.85,75.74 80.44,75.33 80.44,72.96 80.2,71.78 79.74,70.67 79.08,69.67 76.86,67.45 76.44,67.45 76.44,67.45 73.2,67.45 v1(72.76,67.01)
  BOTTOM w0.089: U22.F41 92.16,72.54 v1(92.49,72.21)
N35712957: length 2.3
  BOTTOM w0.762: R619.1 51.25,17.37 C484.1
  vias: v1(49.56,11.61)
N35788414:
  vias: v1(162.34,65.45)
N35788542: length 4.5
  BOTTOM w0.381: PC196.1 165.89,59.11 v1(165.26,59.74) 165.23,59.76 164.09,59.76 163.74,60.12 PU12.4
  BOTTOM w0.508: PR222.1 PC196.1
N35790435: length 4.5
  BOTTOM w0.127: PR188.1 PR195.1 161.2,62.7 PC186.1 161.2,62.37 PU12.2
N35858654: length 2.4
  TOP w0.127: v1(58.44,74.72) PC20.1
  TOP w0.508: PC20.1 PR12.2
N35858977: length 2.9
  BOTTOM w0.635: PR152.1 v1(53.2,72.61) 53.71,73.13 PQ14.4
N35935566: length 2.3
  BOTTOM w0.127: PR137.2 35.5,78.5 v1(35.47,78.54)
  BOTTOM w0.508: PR137.2 PC134.1
N36056010: length 11
  IN2 w0.508: v1(18.73,66.85) 18.73,66.62 16.67,64.57 16.67,63.55 17.18,63.04 17.18,58.72 16.62,58.16 v1(16.57,58.16)
  BOTTOM w0.483: PR221.1 v1(16.57,58.16)
N36056030: length 3.8
  BOTTOM w0.178: PU11.6 16.97,61.94 16.54,61.52 v1(15.91,61.52) 15.91,60.88 16.1,60.69 PR216.1 PR217.2
N36056032:
  vias: v1(20.23,62.03)
N36056052: length 1.9
  BOTTOM w0.127: v1(18.32,59.61) 18.02,59.91 PR217.1
  BOTTOM w0.178: PR221.2 PR217.1
N36056070:
  vias: v1(16.03,65.2)
N36056085: length 3.9
  BOTTOM w0.178: PU11.5 17.92,61.41 v1(18.45,60.88) 18.96,60.37 18.96,58.97 PR215.1
N36138734: length 2
  TOP w0.127: C119.1 81.19,63.43 R634.2 80.35,63.37 v1(80.17,63.55)
N36138851: length 1.1
  TOP w0.127: C78.1 99.07,76.27 R633.2
N36374513: length 4.1
  TOP w0.127: R636.2 62.39,59.99 v1(62.9,60.5) 63.28,60.5 63.79,61.01 R637.2 63.28,61.38 63.14,61.25 U34.1
N40446319: length 1.6
  TOP w0.127: TP9.1 88.78,69.59 v1(89.46,68.92)
  BOTTOM w0.089: v1(89.46,68.92) U22.R46
N40446321: length 3.2
  TOP w0.127: TP13.1 87.54,70.41 87.92,70.03 87.92,69.75 v1(88.75,68.92)
  BOTTOM w0.089: v1(88.75,68.92) U22.R48
N40523681: length 5.7
  BOTTOM w0.14: U22.Y55 85.94,66.39 84.08,66.39 83.02,65.33 v1(81.82,65.33) 81.57,65.33 R497.1
N40708508: length 9.7
  BOTTOM w0.254: R500.2 166.32,62.66 165.81,63.17 164.88,63.17 164.62,63.42 164.62,64.82 162.92,66.52 162.92,68.04 C392.2
  vias: v1(165.39,71.42) v2(164.24,71.78) v2(164.17,70.99) v2(164.57,70.05) v2(164.98,70.69)
N41869277: length 2.1
  BOTTOM w0.127: C396.2 171.09,63.56 v1(171.1,63.55)
  BOTTOM w0.254: R494.1 C396.2
N42791542: length 2.9
  TOP w0.127: v1(84.89,69.21) 84.89,69.24 TP12.1
  BOTTOM w0.089: U22.P53 86.35,69.06 86.1,68.81 85.29,68.81 v1(84.89,69.21)
N42791545: length 5.9
  TOP w0.127: v1(82.56,68.38) 82.56,68.78 TP15.1
  BOTTOM w0.089: 83.69,69.2 83.92,69.43 83.92,69.58 84.42,70.08 85.69,70.08 85.81,69.96 U22.M55
  BOTTOM w0.14: v1(82.56,68.38) 82.86,68.38 83.69,69.2
N42791548: length 1.7
  TOP w0.127: v1(87.28,70.97) 87.15,71.09 TP8.1
  BOTTOM w0.079: 86.96,70.47 U22.L53
  BOTTOM w0.089: v1(87.28,70.97) 87.28,70.8 86.96,70.47
N3442740345: length 8.2
  BOTTOM w0.089: 111.54,73.3 110.62,72.39 110.62,71.19 109.85,70.41 U22.L2
  BOTTOM w0.127: TP52.1 114.43,74.6 113.57,73.73 112.1,73.73 111.67,73.3 111.54,73.3
N3442740355: length 7.6
  BOTTOM w0.089: U22.L3 108.89,70.41 109.07,70.6 109.22,70.7 109.35,70.7 109.49,70.6 109.5,70.59 109.78,70.59 110.45,71.26 110.45,72.49 111.69,73.73
  BOTTOM w0.127: TP51.1 113.16,74.06 112.02,74.06 111.69,73.73

## Copper pours and planes (outline as drawn)
+1.2V on BOTTOM (solid shape): outline of 133 points within 115.48,79.93 124.04,88.57
+1.2VSUS on TOP (solid shape): 147.73,34.72 147.73,32.18 147.61,32.05 147.02,32.05 146.74,32.33 142.12,32.33 142.02,32.43 142.02,33.7 142.15,33.83 143.56,33.83 143.61,33.78 143.62,33.77 143.63,33.75 144.2,33.45 144.05,34.08 144.03,34.08 144.01,34.1 144,34.14 144.01,34.17 144.18,34.34 146.46,34.34 146.97,34.85 147.61,34.85
+1.2VSUS on TOP (solid shape): 136.18,43.85 136.18,43.23 136.68,42.72 139.35,42.72 139.99,42.09 139.99,41.56 139.87,41.45 139.87,40.53 139.88,40.46 139.89,40.35 139.88,40.33 139.86,40.31 139.48,40.31 139.35,40.44 139.35,40.61 139.37,40.63 139.38,40.64 139.57,40.94 139.4,41.26 139.17,41.31 138.97,41.21 138.9,41.18 138.83,41.21 137.83,42.21 134.91,42.21 133.98,43.14 133.98,43.16 133.94,43.3 133.85,43.42 133.64,43.64 133.64,43.99 133.89,44.25 135.78,44.25
+1.2VSUS on TOP (solid shape): 147.73,59.49 147.73,58.47 147.61,58.34 144.56,58.34 144.3,58.09 143.42,58.09 143.34,58.16 143.34,58.18 143.35,58.23 143.35,58.3 143.35,58.37 143.34,58.44 143.32,58.51 143.29,58.57 143.25,58.63 143.21,58.69 143.16,58.74 143.63,58.74 143.63,58.68 143.63,58.63 143.65,58.58 143.67,58.53 143.7,58.49 143.74,58.45 143.78,58.42 143.83,58.39 143.88,58.37 143.93,58.36 143.98,58.35 144.03,58.36 144.09,58.37 144.14,58.39 144.18,58.42 144.22,58.45 144.26,58.49 144.29,58.53 144.31,58.58 144.33,58.63 144.34,58.68 144.34,58.74 144.33,58.79 144.31,58.84 144.29,58.89 144.26,58.93 144.22,58.97 144.18,59 144.14,59.03 144.09,59.05 144.03,59.06 143.98,59.07 143.93,59.06 143.88,59.05 143.83,59.03 143.78,59 143.74,58.97 143.7,58.93 143.67,58.89 143.65,58.84 143.63,58.79 143.63,58.74 143.16,58.74 142.97,58.93 142.97,59.54 143.17,59.74 147.48,59.74
+1.2VSUS on TOP (solid shape): 134.5,62.15 134.59,62.11 134.6,62.02 134.59,61.96 134.58,61.89 134.58,58.75 134.53,58.7 134.17,58.7 134.13,58.71 134.12,58.75 134.12,59.38 133,60.49 133,61.04 133.05,61.13 133.15,61.13 133.71,61.47 133.15,61.8 133.05,61.81 133,61.89 133,62.12 133.03,62.15
+1.2VSUS on TOP (solid shape): 134.03,52.12 134.06,52.11 134.08,52.09 134.18,51.99 134.32,51.93 134.33,51.93 134.53,51.74 134.53,51.36 134.58,51.31 134.58,51.25 134.6,51.2 134.6,51.17 134.58,51.15 134.4,50.94 134.34,50.68 134.34,49.38 134.21,49.25 134.21,48.32 134.07,48.18 132.24,48.18 132.11,48.31 132.11,49.94 133.2,51.03 133.38,51.4 133.09,51.69 133.07,51.7 133.05,51.72 133.05,51.83 133.05,51.91 133.03,51.98 133.03,52.01 133.04,52.03 133.13,52.12
+1.2VSUS on TOP (solid shape): 147.48,51.87 147.48,49.45 147.35,49.33 147.1,49.33 146.34,50.09 142.4,50.09 142.02,50.47 142.02,50.96 142.07,51.02 142.1,51.03 142.12,51.02 142.43,51.06 142.59,51.32 142.6,51.36 142.64,51.37 143.76,51.37 143.78,51.36 143.8,51.35 144.23,51.24 144.44,51.63 144.43,51.65 144.44,51.67 144.69,51.92 145.88,51.92 145.96,51.89 145.98,51.81 146.39,51.38 146.73,51.86 146.73,51.87 146.74,51.91 146.78,51.92 146.85,51.92 146.89,51.92 147.2,51.92 147.27,51.99 147.35,51.99
+1.2VSUS on TOP (solid shape): outline of 220 points within 136.05,57.33 139.86,62.15
+1.2VSUS on TOP (solid shape): 138.4,35.1 138.48,35.06 138.56,34.75 138.82,34.63 138.83,34.59 138.82,34.53 138.68,34.39 138.67,34.39 138.58,33.93 139.04,34.02 139.04,34.03 139.18,34.17 139.2,34.17 139.38,34.24 139.5,34.38 139.58,34.43 139.67,34.41 139.73,34.34 139.73,30.53 139.61,30.4 136.56,30.4 136.43,30.53 136.43,31.04 136.05,31.42 134.27,31.42 134.07,31.62 134.06,31.63 133.96,31.77 133.82,31.87 132.95,32.74 132.95,33.15 132.99,33.24 133.08,33.25 133.54,33.59 133.08,33.94 132.99,33.95 132.95,34.03 132.96,34.17 133.13,34.34 134.21,34.34 134.52,34.03 134.53,34.01 134.53,33.96 134.83,33.66 134.83,33.64 135.18,33.3 135.54,33.64 135.54,33.66 135.83,33.95 135.83,34.01 135.85,34.07 135.88,34.09 136.05,34.09 136.47,34.5 136.58,34.52 136.64,34.43 136.64,33.91 136.89,33.66 136.89,33.37 137.22,33.05 137.23,33.03 137.23,33 137.73,32.61 137.75,33.24 137.7,33.33 137.94,33.73 137.7,34.13 137.75,34.22 137.94,34.52 137.77,34.83 137.72,34.92 137.78,35.01 137.83,35.04 137.88,35.09 137.89,35.1 137.91,35.1
+1.2VSUS on TOP (solid shape): outline of 9734 points within 48.85,16.99 111.79,41.45
+1.2VSUS on BOTTOM (solid shape): 148.05,23.59 149.16,23.59 149.39,23.37 149.39,22.93 149.17,22.71 148.27,22.71 147.31,23.67 146.91,23.67 146.91,23.68 145.96,23.68 145.94,23.7 145.94,23.83 145.96,23.87 146,23.88 146.91,23.88 146.93,23.91 147.74,23.91
+1.2VSUS on BOTTOM (solid shape): 147.73,34.72 147.73,32.43 147.63,32.33 147.3,32.33 146.69,32.94 144.79,32.94 144.54,32.69 143.8,32.69 143.39,33.09 143.39,33.76 143.63,33.76 143.63,33.7 143.63,33.65 143.65,33.6 143.67,33.55 143.7,33.51 143.74,33.47 143.78,33.44 143.83,33.41 143.88,33.39 143.93,33.38 143.98,33.37 144.03,33.38 144.09,33.39 144.14,33.41 144.18,33.44 144.22,33.47 144.26,33.51 144.29,33.55 144.31,33.6 144.33,33.65 144.34,33.7 144.34,33.76 144.33,33.81 144.31,33.86 144.29,33.91 144.26,33.95 144.22,33.99 144.18,34.02 144.14,34.05 144.09,34.07 144.03,34.08 143.98,34.09 143.93,34.08 143.88,34.07 143.83,34.05 143.78,34.02 143.74,33.99 143.7,33.95 143.67,33.91 143.65,33.86 143.63,33.81 143.63,33.76 143.39,33.76 143.39,34.31 143.4,34.33 145.95,34.33 145.97,34.34 146.34,34.34 146.84,34.85 147.61,34.85
+1.2VSUS on BOTTOM (solid shape): 136.79,41.73 136.88,41.67 136.87,41.57 136.8,41.4 136.82,41.23 136.82,41.22 136.82,40.53 136.92,40.43 136.92,40.42 137.01,40.31 137.14,40.25 137.2,40.22 137.23,40.15 137.23,40.11 137.2,40.04 137.14,40.01 137.07,39.99 137.01,39.95 136.66,39.95 136.1,40.51 136.1,40.75 136.05,40.8 136.05,41.37 136.08,41.41 136.11,41.41 136.13,41.41 136.45,41.42 136.63,41.69 136.65,41.72 136.68,41.73
+1.2VSUS on BOTTOM (solid shape): 143.82,59.29 147.17,59.29 147.61,58.85 147.61,58.47 147.33,58.19 147.2,58.19 147.1,58.17 147.01,58.09 146.98,58.09 143.86,58.09 143.83,58.1 143.81,58.14 143.81,58.15 143.84,58.21 143.98,58.35 144,58.35 144.23,58.96 143.63,58.73 143.62,58.71 143.48,58.57 143.48,58.57 143.33,58.43 143.31,58.22 143.3,58.13 143.22,58.09 142.71,58.09 142.4,58.4 142.4,58.98 143.01,59.59 143.52,59.59
+1.2VSUS on BOTTOM (solid shape): 143.85,41.83 143.92,41.82 146.21,41.82 146.75,41.29 146.82,41.29 146.85,41.28 146.87,41.26 147.19,41.03 147.59,41.06 147.69,41.06 147.73,40.97 147.73,39.29 147.48,39.04 146.84,39.04 145.57,40.31 143.94,40.31 143.86,40.35 143.85,40.44 143.86,40.54 143.84,40.64 143.83,40.65 143.83,40.86 143.57,41.12 143.57,41.14 142.96,41.37 143.19,40.77 143.21,40.76 143.3,40.67 143.32,40.65 143.31,40.62 143.3,40.53 143.31,40.44 143.3,40.35 143.22,40.31 142.71,40.31 142.53,40.49 142.53,41.81 142.58,41.86 143.78,41.86
+1.2VSUS on BOTTOM (solid shape): outline of 105 points within 139.83,15.54 144.03,19.48
+1.2VSUS on BOTTOM (solid shape): outline of 150 points within 137.33,39.55 139.99,41.73
+1.2VSUS on BOTTOM (solid shape): 138.4,35.1 138.48,35.06 138.56,34.75 138.82,34.63 138.83,34.59 138.82,34.53 138.68,34.39 138.67,34.39 138.58,33.93 139.04,34.02 139.04,34.03 139.18,34.17 139.2,34.17 139.38,34.24 139.5,34.38 139.58,34.43 139.67,34.41 139.86,34.21 139.86,30.53 139.73,30.4 136.68,30.4 136.43,30.66 136.43,31.93 136.07,32.29 136.07,34.1 136.42,34.46 136.46,34.47 136.49,34.46 136.92,34.03 136.92,34.02 136.98,33.93 137.07,33.87 137.08,33.87 137.22,33.73 137.23,33.71 137.28,33.54 137.41,33.42 137.46,33.33 137.41,33.24 137.58,32.57 137.75,33.24 137.7,33.33 137.94,33.73 137.7,34.13 137.75,34.22 137.94,34.52 137.77,34.83 137.72,34.92 137.78,35.01 137.83,35.04 137.88,35.09 137.89,35.1 137.91,35.1
+1.2VSUS on BOTTOM (solid shape): outline of 91 points within 133.1,57.33 139.86,62.15
+1.2VSUS on SVCC (solid shape): outline of 398 points within 107.35,17.19 149.51,63.68
+1.05V on TOP (solid shape): outline of 154 points within 79.08,53.9 85.49,66.22
+1.5V on BOTTOM (solid shape): 165.13,50.98 165.13,47.67 164.88,47.42 161.07,47.42 160.94,47.55 160.94,48.54 161.09,48.69 163.05,48.69 163.48,49.12 163.48,50.98 163.61,51.1 165.01,51.1
+1.05V on BOTTOM (solid shape): 125.25,79.3 125.38,79.17 125.38,75.56 125.3,75.49 124.24,75.49 124.14,75.59 124.14,76.33 123.88,76.58 123.88,76.67 122.82,76.67 122.78,76.63 122.76,76.63 122.41,76.63 122.39,76.63 122.37,76.65 122.35,76.67 121.41,76.67 121.32,76.76 121.32,76.9 121.32,76.91 121.39,77.14 121.32,77.37 121.32,77.38 121.32,77.42 121.32,77.45 121.34,77.46 121.49,77.72 121.42,78.01 121.42,78.22 122.03,78.83 123.57,78.83 124.04,79.3 124.59,79.3
+1.5V on IN2 (solid shape): outline of 219 points within 159.29,22.27 166.16,48.74
+1.05V on IN2 (solid shape): outline of 3281 points within 71.94,46.02 128.12,78.97
+1.5VA on TOP (solid shape): 173.78,21.76 173.78,21.49 173.79,21.48 173.79,21.46 173.83,21.37 173.9,21.31 173.92,21.3 173.92,21.01 173.93,21 173.93,20.97 174.4,20.5 174.4,19.23 174.24,19.06 173.81,19.06 173.38,19.49 173.38,20.94 172.82,21.5 172.17,21.5 172.14,21.53 172.14,21.77 173.05,21.77 173.18,21.91 173.63,21.91
+1.8V_S5 on TOP (solid shape): 62.39,89.71 62.39,89.08 63.91,87.55 63.91,85.32 62.52,83.92 59.32,83.92 59.21,84.02 59.21,89.84 59.34,89.97 62.14,89.97
+1.8V_S5 on TOP (solid shape): 81.03,10.74 81.03,10.03 80.93,9.93 80.83,9.93 80.43,10.33 80.43,10.33 80.37,10.39 80.37,10.51 80.3,10.59 79.13,10.59 79.1,10.62 79.1,10.79 79.15,10.84 80.93,10.84
+1.8V_S5 on TOP (solid shape): outline of 88 points within 67.22,53.52 68.99,55.8
+1.8V_S5 on BOTTOM (solid shape): 107.92,83.55 107.97,83.51 108.03,83.47 108.11,83.39 108.11,83.11 107.98,82.98 105.82,82.98 105.78,82.99 105.77,83.03 105.77,83.74 106.71,84.68 106.79,84.68
+1.8V_S5 on BOTTOM (solid shape): 26.45,68.25 26.45,68.01 26.39,67.81 26.44,67.61 26.45,67.59 26.52,67.51 26.52,67.49 26.52,61.34 26.45,61.26 24.66,61.26 24.6,61.33 22.52,61.33 22.31,61.54 22.31,62.36 22.49,62.53 24.54,62.53 24.92,62.91 24.92,62.97 24.95,62.99 24.95,66.96 24.78,67.12 24.56,67.12 24.34,67.33 23.58,67.33 23.55,67.36 23.55,67.46 24.04,67.94 24.16,67.94 24.17,67.95 24.69,67.95 25.12,68.38 26.32,68.38
+1.8V_S5 on IN1 (solid shape): 62.39,89.97 62.39,88.77 62.19,88.57 57.73,88.57 55.95,86.79 54.52,86.79 47.54,79.82 24.54,79.82 24.53,79.81 24.16,79.81 23.91,80.06 23.91,81.58 24.04,81.71 26.19,81.71 26.59,81.32 34.61,81.32 34.64,81.31 34.66,81.29 34.96,81.13 35.26,81.29 35.28,81.31 35.3,81.32 46.16,81.32 53.47,88.63 55.31,88.63 56.85,90.17 62.19,90.17
+1.8V_S5 on IN2 (solid shape): outline of 3866 points within 61.25,50.6 107.22,88.19
+1.8V_S5 on IN3 (solid shape): 80.55,70.71 80.58,70.7 80.59,70.69 80.6,70.66 80.6,67.55 80.93,67.22 80.93,66.44 80.92,66.41 80.91,66.4 80.88,66.39 80.12,66.39 80.02,66.29 79.69,66.29 79.39,65.99 78.83,65.99 78.75,65.99 78.59,66.14 78.59,68.38 79.27,68.38 79.27,68.32 79.29,68.26 79.31,68.21 79.33,68.16 79.37,68.12 79.41,68.08 79.45,68.05 79.5,68.02 79.56,68.01 79.61,68 79.67,67.99 79.72,68 79.78,68.01 79.83,68.04 79.87,68.06 79.92,68.1 79.95,68.14 79.99,68.19 80.01,68.24 80.02,68.29 80.03,68.35 80.03,68.4 80.02,68.46 80.01,68.51 79.99,68.56 79.95,68.61 79.92,68.65 79.87,68.69 79.83,68.71 79.78,68.74 79.72,68.75 79.67,68.76 79.61,68.75 79.56,68.74 79.5,68.73 79.45,68.7 79.41,68.67 79.37,68.63 79.33,68.59 79.31,68.54 79.29,68.49 79.27,68.43 79.27,68.38 78.59,68.38 78.59,68.56 79.42,69.38 80.14,70.46 80.25,70.7 80.28,70.71
+1.8V_S5 on IN3 (solid shape): 24.95,82.85 24.97,82.85 24.99,82.83 25.26,82.67 25.56,82.76 25.63,82.79 25.69,82.77 25.99,82.68 26.25,82.83 26.26,82.84 26.28,82.85 26.83,82.85 27.21,82.47 27.21,79.4 25.94,78.13 25.94,76.25 25.2,75.51 25.2,74.87 25.2,74.85 25.14,74.78 25.14,69.06 25.43,68.77 25.43,67.49 25.28,67.33 23.73,67.33 23.53,67.54 23.53,69.26 23.36,69.43 23.34,69.47 23.3,69.52 23.25,69.57 22.87,69.95 22.87,71.27 22.94,71.5 22.87,71.73 22.87,79.5 23.53,80.16 23.53,82.35 24.04,82.85
+1.24V_S5 on TOP (solid shape): 116.08,66.34 119.16,66.34 119.16,66.34 122.05,66.34 122.48,65.92 122.48,62.91 122.26,62.69 121.22,62.69 120.4,63.5 119.87,63.5 119.72,63.35 119.67,63.3 119.62,63.25 119.46,63.09 119.46,60.96 119.16,60.66 118.92,60.66 118.56,60.29 118.56,60.03 118.14,59.61 115.98,59.61 115.86,59.74 115.86,60.12 115.6,60.37 113.95,60.37 113.82,60.5 113.82,61.39 113.95,61.52 117.25,61.52 117.51,61.77 117.52,61.77 117.52,62.79 117.51,62.79 117.51,63.29 117.52,63.29 117.52,64.31 117.51,64.31 117.38,64.44 116.39,64.44 114.74,64.44 114.43,64.74 112.1,64.74 111.94,64.9 108.54,64.9 108.46,64.97 107.5,64.97 107.42,65.05 107.42,65.12 107.35,65.2 107.35,65.84 107.47,65.96 108.24,65.96 108.49,65.71 113.32,65.71 113.32,65.7 114.33,65.7 114.33,65.71 114.61,65.98 115.23,65.98 115.23,65.98 115.56,66.02 115.73,66.3 115.74,66.33 115.78,66.34 116.08,66.34
+1.24V_S5 on BOTTOM (solid shape): 126.57,65.81 126.57,64.63 126.33,64.39 125.95,64.33 125.81,63.98 125.81,62.27 125.61,62.07 121.96,62.07 120.73,63.3 120.73,63.5 123.2,65.96 126.42,65.96
+2.5V_SUS on TOP (solid shape): 114.97,27.35 114.97,25.7 114.71,25.45 113.7,25.45 113.44,25.7 113.44,26.08 113.57,26.21 113.57,27.35 113.82,27.61 114.71,27.61
+2.5V_SUS on TOP (solid shape): 117.42,18.95 117.43,18.94 117.45,18.93 117.72,18.82 117.99,18.93 118.01,18.94 118.03,18.95 119.62,18.95 119.79,18.77 119.79,16.58 119.64,16.43 116.11,16.43 115.98,16.56 115.98,18.79 116.14,18.95
+2.5V_SUS on BOTTOM (solid shape): outline of 485 points within 113.09,18.46 119.23,29.94
+2.5V_SUS on IN2 (solid shape): outline of 1022 points within 117.89,28.65 148.24,61.59
+3V on TOP (solid shape): 156.52,40.89 156.98,40.89 157.08,40.79 157.08,39.23 156.98,39.13 156.33,39.13 153.98,41.48 153.98,42.57 154.18,42.77 154.64,42.77
+3V on TOP (solid shape): 169.62,13.79 169.62,12.53 169.01,11.93 163.77,11.93 163.33,12.37 163.33,13.21 163.49,13.37 164.13,13.37 164.75,12.75 168.15,12.75 168.43,13.03 168.43,13.55 168.85,13.96 169.45,13.96
+3V on TOP (solid shape): 169.69,78.79 169.71,78.79 169.72,78.77 169.82,78.71 169.92,78.66 169.95,78.65 169.96,78.61 169.96,78.44 169.96,77.26 169.83,77.14 169.04,77.14 168.85,77.33 168.85,78.18 168.85,78.18 168.82,78.21 168.82,78.66 168.94,78.79
+3V on TOP (solid shape): 166.98,76.44 166.98,75.4 166.81,75.23 166.15,75.23 166.02,75.36 165.51,75.36 164.82,74.66 164.61,74.66 164.58,74.68 164.56,74.71 164.56,74.93 164.94,75.31 165.04,75.47 165.07,75.65 165.07,75.66 165.07,75.68 165.26,75.87 166.4,75.87 166.53,76 166.53,76.38 166.66,76.5 166.91,76.5
+3V on TOP (solid shape): 154.72,79.81 154.72,77.39 154.91,77.2 154.91,76.71 155.35,76.26 155.35,75.73 155.3,75.67 155.3,75.31 155.23,75.23 153.83,75.23 153.7,75.36 153.7,75.74 153.58,75.87 151.92,75.87 151.42,76.38 149.26,76.38 149.19,76.44 149.19,76.82 149.26,76.88 149.64,76.88 149.64,76.89 150,76.89 150.1,76.99 150.1,77.45 150.3,77.65 152.69,77.65 153.45,78.41 153.45,79.81 153.58,79.93 154.59,79.93
+3V on TOP (solid shape): 153.32,63.04 153.32,62.53 153.32,62.52 153.46,62.04 153.96,62.02 153.97,62.03 154.09,62.03 154.11,62.02 154.13,62.01 154.42,61.85 154.74,61.94 154.75,61.96 154.79,61.95 154.85,61.9 154.85,60.25 154.72,60.12 153.07,60.12 152.94,60.25 152.94,61.26 152.89,61.32 152.82,61.4 152.73,61.47 152.69,61.52 151.92,61.52 151.67,61.77 151.67,62.26 151.67,62.32 151.69,62.38 151.69,62.81 151.67,62.87 151.67,62.96 151.69,63.01 151.69,63.06 151.8,63.17 153.19,63.17
+3V on BOTTOM (solid shape): 20.61,16.31 20.61,15.04 20.35,14.78 19.21,14.78 18.96,15.04 18.96,16.31 19.21,16.56 20.35,16.56
+3V on BOTTOM (solid shape): 139.35,20.93 139.35,20.01 138.82,19.48 137.07,19.48 136.94,19.61 136.94,20.32 136.95,20.35 136.99,20.37 137.6,20.37 137.95,20.72 137.95,20.75 138.26,21.05 139.22,21.05
+3V on BOTTOM (solid shape): 99.55,90.29 100.01,90.29 100.07,90.29 100.26,90.29 100.34,90.21 100.34,89.95 100.29,89.89 100.11,89.89 100.07,89.89 99.5,89.89 99.24,90.15 99.22,90.17 98.69,90.17 98.58,90.27 98.58,90.7 98.63,90.75 99.09,90.75
+3V on BOTTOM (solid shape): 102.84,90.16 102.88,90.13 102.93,90.09 103.05,89.97 103.36,89.97 103.41,89.91 103.41,89.48 103.36,89.43 102.85,89.43 102.41,89.88 102.36,89.88 102.34,89.89 101.67,89.89 101.61,89.89 101.55,89.88 101.3,89.88 101.26,89.89 101.24,89.93 101.24,90.22 101.29,90.26 102.74,90.26
+3V on BOTTOM (solid shape): 151.21,65.9 151.86,65.9 151.89,65.87 151.91,65.76 151.82,65.7 151.21,65.7 151.21,65.5 152,65.5 152.04,65.48 152.05,65.45 152.05,64.77 152.05,64.77 152.05,64.08 152.86,63.27 152.86,62.25 152.15,61.54 148.32,61.54 148.11,61.75 148.13,61.76 148.13,61.89 148.11,61.9 148.11,65.07 148.24,65.2 149.26,65.2 149.64,65.58 150.65,65.58 150.98,65.91 151.21,65.91
+3V on IN2 (solid shape): outline of 8296 points within 19.15,12.84 169.96,79.04
+3V on IN3 (solid shape): outline of 201 points within 115.35,76.63 118.52,89.52
+3V on IN3 (solid shape): outline of 956 points within 138.21,5.13 170.75,21.5
+3V_EMMC on TOP (solid shape): 62.27,56.61 62.27,56.07 62.02,55.82 62.02,55.24 62.26,54.74 62.81,54.63 62.81,54.63 63.47,54.63 63.5,54.62 63.52,54.6 63.6,54.48 63.71,54.39 63.86,54.36 64.02,54.38 64.11,54.37 64.16,54.29 64.16,54.24 64.17,54.19 64.17,53.67 64.09,53.59 63.39,53.59 63.28,53.7 63.28,53.71 63.22,53.83 63.13,53.93 63.06,53.97 62.99,53.99 62.64,53.89 62.54,53.54 62.53,53.51 62.52,53.49 62.38,53.35 61.38,53.35 60.97,53.77 60.57,53.77 60.57,53.77 60.44,53.8 60.31,53.77 60.3,53.77 60.26,53.77 60,53.52 59.78,53.52 59.7,53.59 59.7,55.16 59.54,55.32 59.09,55.32 58.66,55.75 58.66,56.46 58.86,56.66 62.22,56.66
+3V_EMMC on BOTTOM (solid shape): 62.14,54.35 62.14,52.82 61.45,52.13 61.28,52.13 61.2,52.22 61.2,52.37 61.02,52.55 60.83,52.55 60.75,52.63 60.75,52.92 60.79,52.96 60.99,52.96 61.17,53.14 61.17,53.9 61.17,54.33 61.25,54.41 62.08,54.41
+3V_EMMC on BOTTOM (solid shape): 62.95,54.86 63.2,54.61 63.23,54.6 63.24,54.59 63.34,54.54 63.48,54.55 63.51,54.53 63.66,54.38 64.09,54.38 64.17,54.3 64.17,53.67 64.09,53.59 63.61,53.59 63.59,53.61 63.58,53.63 63.58,53.66 63.58,53.81 63.48,53.92 63.48,53.93 63.4,54 62.83,54 62.66,54.18 62.66,54.69 62.83,54.86
+3V_HDMI on TOP (solid shape): outline of 115 points within 111.61,74.22 117,88.31
+3V_MINI1_VDD on TOP (solid shape): 19.97,20.32 20.88,20.32 21.29,19.91 21.32,19.91 21.35,19.9 21.37,19.86 21.37,18.74 21.35,18.71 21.33,18.71 21.04,18.47 21.1,18.1 21.11,18.07 21.09,18.04 20.6,17.55 19.69,17.55 19.62,17.47 19.36,17.47 19.06,17.78 19.06,18.46 19.22,18.63 19.24,18.64 19.26,18.64 19.62,18.84 19.59,19.25 19.59,19.5 19.67,19.73 19.59,19.95 19.59,20.17 19.79,20.37 19.91,20.37
+3V_MINI1_VDD on BOTTOM (solid shape): 18.38,15.89 18.38,12.53 18.17,12.32 17.25,12.32 16.95,12.62 16.95,13.36 16.29,14.02 16.29,15.8 16.72,16.23 18.04,16.23
+3V_MINI1_VDD on BOTTOM (solid shape): 46.99,18.16 48.47,18.16 49.19,17.44 49.19,17.14 49.49,17.14 49.51,17.07 49.47,17 49.34,16.84 49.31,16.63 49.38,16.46 49.53,16.34 49.59,16.26 49.56,16.17 49.51,16.12 49.51,13.93 47.66,12.08 47.39,12.08 47.29,12.17 47.29,13.34 48.8,14.86 48.8,16.01 48.71,16.1 47.43,16.1 47.25,16.28 47.25,16.99 47.15,17.09 45.75,17.09 45.65,17.19 45.65,18.18 45.8,18.34 46.81,18.34
+3V_MINI1_VDD on BOTTOM (solid shape): outline of 116 points within 17.18,22.44 22.28,28.12
+3V_MINI1_VDD on BOTTOM (solid shape): outline of 148 points within 35.47,10.34 42.2,16.31
+3V_MINI1_VDD on BOTTOM (solid shape): outline of 355 points within 25.69,15.09 41.56,29.63
+3V_MINI1_VDD on IN1 (solid shape): outline of 724 points within 16.11,14.02 27.59,25.96
+3V_MINI1_VDD on IN2 (solid shape): outline of 963 points within 16.24,6.5 47.83,15.75
+3V_MINI1_VDD on IN3 (solid shape): outline of 368 points within 27.21,19.73 41.43,29.01
+3V_S5 on TOP (solid shape): 110.4,19.1 110.4,18.46 111.28,17.58 111.28,15.04 111.03,14.78 110.96,14.78 110.93,14.81 110.93,14.82 109.86,14.82 109.86,14.81 109.83,14.78 109.63,14.78 107.96,16.46 107.96,18.72 107.96,18.74 107.96,18.95 108.24,19.23 110.27,19.23
+3V_S5 on TOP (solid shape): 102.89,68.11 102.99,68.12 103.41,68.12 103.54,67.99 103.54,67.11 103.41,66.98 103.03,66.98 102.65,66.6 101.63,66.6 101.51,66.47 101.51,66.09 101.38,65.96 101.12,65.96 101,66.09 101,67.36 101.12,67.49 101.51,67.49 102.14,68.12 102.78,68.12
+3V_S5 on BOTTOM (solid shape): 20.02,13.84 20.02,12.19 19.84,12.01 19.84,11.1 19.59,10.84 19.08,10.84 18.83,11.1 18.83,13.79 19.06,14.02 19.84,14.02
+3V_S5 on BOTTOM (solid shape): 89.06,18.85 89.06,17.32 89.44,16.94 89.44,16.31 89.31,16.18 87.66,16.18 86.9,16.94 86.9,18.85 87.03,18.97 88.93,18.97
+3V_S5 on BOTTOM (solid shape): 41.69,17.7 41.69,16.31 41.62,16.24 40.24,16.24 40.09,16.09 38.19,16.09 37.7,16.59 37.7,17.46 37.79,17.55 38.13,17.55 38.18,17.49 38.25,17.44 39.04,16.66 39.45,16.66 39.76,16.59 40.01,16.78 40.02,16.79 40.06,16.84 40.06,17.62 40.27,17.83 41.56,17.83
+3V_S5 on BOTTOM (solid shape): 101.98,68.25 102.12,68.22 102.26,68.25 102.27,68.25 102.53,68.25 103.15,67.63 103.15,67.5 102.6,66.95 102.6,66.47 102.5,66.37 102.39,66.37 102.36,66.38 102.34,66.4 101.98,66.61 101.61,66.42 101.59,66.4 101.57,66.4 101.46,66.4 101.38,66.47 101.38,68.12 101.51,68.25 101.97,68.25
+3V_S5 on BOTTOM (solid shape): outline of 84 points within 147.35,67.21 152.05,74.73
+3V_S5 on IN2 (solid shape): outline of 356 points within 16.42,10.72 21.39,57.58
+3V_S5 on IN2 (solid shape): outline of 13507 points within 24.19,16.23 150.58,82.38
+3V_S5 on IN3 (solid shape): 25.66,17.27 25.66,17.09 22.64,14.07 22.64,13.06 22.26,12.67 22.26,12.09 22.26,12.08 22.24,12.06 22.21,12.04 22.17,12 22.14,11.96 22.11,11.91 22.09,11.86 22.07,11.81 22.06,11.76 22.06,11.7 22.07,11.65 22.09,11.6 22.11,11.55 22.14,11.5 22.18,11.46 22.22,11.41 22.23,11.39 22.23,11.36 22.22,11.33 22.2,11.3 21.67,10.77 18.9,10.77 18.83,10.84 18.83,11.76 19.88,11.76 19.89,11.7 19.9,11.65 19.92,11.6 19.95,11.55 19.98,11.5 20.02,11.46 20.07,11.43 20.12,11.41 20.17,11.39 20.22,11.38 20.28,11.38 20.34,11.38 20.39,11.4 20.44,11.42 20.49,11.45 20.53,11.48 20.57,11.52 20.6,11.57 20.62,11.62 20.64,11.68 20.65,11.73 20.65,11.79 20.64,11.84 20.62,11.89 20.6,11.95 20.57,11.99 20.53,12.03 20.49,12.07 20.44,12.1 20.39,12.12 20.34,12.13 20.28,12.14 20.22,12.14 20.17,12.13 20.12,12.11 20.07,12.08 20.02,12.05 19.98,12.01 19.95,11.97 19.92,11.92 19.9,11.87 19.89,11.81 19.88,11.76 18.83,11.76 18.83,11.86 20.82,13.85 20.82,17.03 21.32,17.52 25.41,17.52
+3VPCU on TOP (solid shape): 25.83,22.03 25.83,21.16 25.68,21 24.04,21 23.97,21.07 23.97,22.16 23.99,22.2 24.02,22.21 24.85,22.21 24.92,22.27 24.97,22.27 25.18,22.49 25.37,22.49
+3VPCU on TOP (solid shape): 22.38,78.38 22.38,76.88 22.26,76.76 21.88,76.76 21.75,76.63 21.75,75 21.62,74.64 21.73,74.26 21.75,74.25 21.74,74.21 21.7,74.17 21.29,74.17 21.24,74.22 21.24,78.38 21.27,78.41 21.65,78.79 21.97,78.79
+3VPCU on TOP (solid shape): 171.74,9.83 171.74,9.57 171.61,9.45 171.48,9.45 171.35,9.32 171.35,7.92 171.21,7.78 171.21,7.78 171.07,7.62 171.02,7.42 171.03,7.3 171.08,7.15 171.07,7.13 170.97,7.03 170.47,7.03 170.34,7.16 170.34,9.57 170.69,9.93 171.41,9.93 171.44,9.95 171.46,9.96 171.61,9.96
+3VPCU on TOP (solid shape): 84.21,88.64 84.21,87.6 84.11,87.5 78.13,87.5 78.11,87.52 78.06,87.54 78.01,87.56 77.96,87.57 77.91,87.57 77.86,87.57 77.81,87.56 77.76,87.54 77.71,87.52 77.69,87.5 76.47,86.28 71.53,86.28 71.36,86.46 71.36,87.3 74.45,87.3 74.46,87.24 74.47,87.19 74.49,87.14 74.52,87.09 74.55,87.04 74.59,87 74.64,86.97 74.69,86.95 74.74,86.93 74.79,86.92 74.85,86.92 74.9,86.92 74.96,86.94 75.01,86.96 75.06,86.99 75.1,87.02 75.14,87.06 75.17,87.11 75.19,87.16 75.21,87.21 75.22,87.27 75.22,87.33 75.21,87.38 75.19,87.43 75.17,87.48 75.14,87.53 75.1,87.57 75.06,87.61 75.01,87.64 74.96,87.66 74.9,87.67 74.85,87.68 74.79,87.68 74.74,87.67 74.69,87.65 74.64,87.62 74.59,87.59 74.55,87.55 74.52,87.51 74.49,87.46 74.47,87.41 74.46,87.35 74.45,87.3 71.36,87.3 71.36,88.62 71.48,88.75 84.11,88.75
+3VPCU on TOP (solid shape): 43.19,23.04 43.28,22.97 43.26,22.86 42.83,22.43 42.83,20.08 42.83,19.99 42.06,19.21 42.05,19.21 41.95,19.14 41.88,19.04 41.88,19.03 41.82,18.97 41.82,18.21 41.87,18.15 41.88,18.14 42.15,17.87 42.52,17.97 42.59,18 42.66,17.97 42.98,17.86 43.26,18.05 43.27,18.06 43.31,18.08 43.89,18.08 43.93,18.05 43.94,18.03 44.24,17.78 44.6,17.93 44.68,17.97 44.75,17.94 45.37,17.32 45.37,14.78 45.24,14.65 44.86,14.65 44.86,16.4 43.95,17.32 41.65,17.32 41.22,17.75 41.22,17.75 41.12,17.85 40.6,17.85 40.59,17.84 40.46,17.84 40.42,17.88 40.37,17.88 40.29,17.97 40.29,18.34 40.37,18.42 40.37,18.97 40.63,19.23 41.18,19.23 41.31,19.35 41.31,19.86 41.82,20.37 41.82,20.75 41.89,20.82 41.89,22.09 42.83,23.04
+3VPCU on BOTTOM (solid shape): 47.21,58.83 47.21,58.3 47.31,58.2 47.33,58.16 47.31,58.12 47.28,58.09 47,58.09 46.88,58.15 46.74,58.17 46.33,58.17 46.2,58.3 46.2,58.41 46.33,58.54 46.33,59.05 46.51,59.23 46.81,59.23
+3VPCU on BOTTOM (solid shape): 136.54,67 136.54,63.91 136.18,63.55 135.16,63.55 134.91,63.8 132.11,63.8 131.73,64.18 131.73,65.96 131.99,66.22 132.64,66.22 132.87,66.15 133.09,66.21 133.1,66.22 133.13,66.22 133.92,67.01 134.2,67.01 134.42,67.23 136.3,67.23
+3VPCU on BOTTOM (solid shape): outline of 241 points within 153.32,60.5 160.05,70.28
+3VPCU on SVCC (solid shape): outline of 228 points within 15.53,20.88 159.67,103.47
+3VPCU_EC on TOP (solid shape): 21.77,29.16 21.77,28.5 21.8,28.47 23.32,28.47 23.37,28.42 23.37,28.34 23.32,28.29 21.83,28.29 21.75,28.22 21.75,27.46 21.62,27.33 20.48,27.33 20.35,27.46 20.35,28.07 20.05,28.37 20.05,28.55 20.2,28.7 20.2,28.85 20.2,29.14 20.22,29.18 20.25,29.2 21.74,29.2
+3VPCU_EC on IN1 (solid shape): outline of 207 points within 19.34,27.86 22.7,40.18
+3VPCU_EC on IN2 (solid shape): outline of 2300 points within 21.39,21.96 44.08,42.59
+5V on TOP (solid shape): 165.59,77.88 165.62,77.87 165.64,77.83 165.64,77.08 166.4,76.32 166.4,76.12 166.28,76 165.39,76 165.38,76 165.04,76 164.5,76.54 164.5,77.75 164.63,77.88
+5V on TOP (solid shape): 123.98,8.45 123.98,6.65 123.86,6.53 121.7,6.53 121.57,6.65 121.57,7.51 121.6,7.54 121.95,7.89 121.95,7.94 121.97,7.97 122,7.99 122.39,7.99 122.45,8.05 122.59,8.05 123.16,8.62 123.81,8.62
+5V on TOP (solid shape): 172.68,32.26 172.68,31.62 172.65,31.6 171.58,31.6 171.18,32 170.21,32 170.09,31.88 170.09,31.11 170.75,30.45 172.65,30.45 173.13,29.97 173.13,27.99 172.16,27.01 171.97,26.91 171.87,26.73 168.69,23.54 167.67,23.54 167.55,23.67 167.55,25.2 167.67,25.32 168.05,25.32 168.28,25.55 168.28,26.11 170.09,27.91 170.09,29.16 169.97,29.27 168.68,29.27 168.46,29.49 168.46,32.41 168.71,32.66 172.27,32.66
+5V on TOP (solid shape): 46.23,21.26 47.25,21.26 47.4,21.1 47.4,15.73 47.35,15.68 46.13,15.68 45.75,16.05 45.75,16.51 45.75,16.53 45.75,17.7 43.21,20.24 43.21,20.88 45.5,20.88 45.5,20.82 45.51,20.77 45.53,20.71 45.56,20.67 45.59,20.62 45.63,20.58 45.68,20.55 45.73,20.53 45.78,20.51 45.84,20.5 45.89,20.5 45.95,20.5 46,20.52 46.05,20.54 46.1,20.57 46.14,20.6 46.18,20.64 46.21,20.69 46.24,20.74 46.25,20.79 46.26,20.85 46.26,20.9 46.25,20.96 46.24,21.01 46.21,21.06 46.18,21.11 46.14,21.15 46.1,21.19 46.05,21.22 46,21.24 45.95,21.25 45.89,21.26 45.84,21.26 45.78,21.25 45.73,21.23 45.68,21.2 45.63,21.17 45.59,21.13 45.56,21.09 45.53,21.04 45.51,20.99 45.5,20.93 45.5,20.88 43.21,20.88 43.21,22.14 43.6,22.53 44.96,22.53
