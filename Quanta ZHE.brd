# Allegro board Quanta ZHE.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5V on TOP (solid shape): 169.64,17.5 169.66,17.49 169.72,17.46 169.77,17.45 169.82,17.45 169.88,17.45 169.93,17.46 169.99,17.48 170.02,17.5 170.19,17.5 170.34,17.35 170.34,16.4 170.67,16.07 170.67,14.93 170.62,14.88 169.22,14.88 168.08,16.03 168.08,16.05 169.45,16.05 169.45,16 169.47,15.94 169.49,15.89 169.51,15.84 169.55,15.8 169.59,15.76 169.63,15.72 169.68,15.7 169.73,15.68 169.79,15.67 169.84,15.67 169.9,15.68 169.95,15.69 170.01,15.71 170.05,15.74 170.1,15.78 170.13,15.82 170.16,15.86 170.19,15.91 170.2,15.97 170.21,16.02 170.21,16.08 170.2,16.13 170.19,16.19 170.16,16.24 170.13,16.28 170.1,16.33 170.05,16.36 170.01,16.39 169.95,16.41 169.9,16.43 169.84,16.43 169.79,16.43 169.73,16.42 169.68,16.4 169.63,16.38 169.59,16.34 169.55,16.31 169.51,16.26 169.49,16.21 169.47,16.16 169.45,16.11 169.45,16.05 168.08,16.05 168.08,17.37 168.21,17.5
+5V on TOP (solid shape): 154.46,8.05 154.49,8.04 154.51,8 154.51,7.21 154.7,7.21 154.71,7.2 154.72,7.21 154.72,7.95 154.74,7.97 154.87,7.97 154.9,7.95 154.9,7.12 154.74,6.96 154.74,6.71 154.72,6.68 154.72,5.13 154.97,4.88 154.97,4.4 155.14,4.23 155.14,4.1 155.14,4.09 155.1,3.86 155.14,3.63 155.14,3.62 155.14,3.37 155.13,3.33 155.09,3.32 152.14,3.32 151.92,3.54 151.92,3.83 151.93,3.84 151.93,4.57 151.68,4.82 151.63,4.87 151.62,4.89 151.61,4.91 151.61,7.59 151.62,7.61 151.63,7.63 151.67,7.67 153.96,7.67 154.34,8.05
+5V on BOTTOM (solid shape): 119.49,92.87 119.52,92.86 119.54,92.82 119.54,90.73 119.03,90.22 119.03,88.95 118.9,88.82 118.02,88.82 117.96,88.87 117.96,92.69 118.15,92.87
+5V on BOTTOM (solid shape): 18.36,18.91 18.54,18.8 18.74,18.79 18.76,18.79 18.78,18.78 18.84,18.72 18.84,17.98 18.83,17.88 18.84,17.78 18.84,17.08 18.45,16.69 17.43,16.69 17.18,16.94 17.18,18.38 17.19,18.41 17.21,18.44 17.23,18.52 17.23,18.59 17.23,18.77 17.43,18.97 18.3,18.97
+5V on SVCC (solid shape): outline of 947 points within 4.29,2.03 173.39,37.64
+5V on IN2 (solid shape): outline of 321 points within 30.83,21.31 44.74,25.75
+5V on IN2 (solid shape): outline of 2051 points within 118.27,23.54 171.74,92
+5V on IN3 (solid shape): 145.53,83.35 145.74,83.35 146.12,83.25 146.5,83.22 152.76,83.22 152.8,83.21 152.81,83.17 152.81,82.6 152.43,82.22 151.98,82.22 151.95,82.24 151.95,82.25 151.23,82.76 150.52,82.25 150.51,82.24 150.49,82.22 145.07,82.22 144.56,82.73 144.56,83.36 144.69,83.49 145.4,83.49
+5V_FAN1 on BOTTOM (solid shape): 23.48,32.23 23.48,31.37 23.4,31.29 22.69,31.29 22.66,31.29 21.88,31.29 21.5,30.91 21.5,30.02 21.31,29.83 21.29,29.83 20.97,29.51 17.81,29.51 17.69,29.64 17.69,30.28 17.81,30.4 19.84,30.4 20,30.55 20,31.85 20.15,32 21.44,32 21.75,32.31 23.4,32.31
+5V_HDD1 on TOP (solid shape): 49.31,17.05 49.32,16.59 49.35,16.52 49.48,16.37 49.66,16.31 49.73,16.27 49.75,16.2 49.75,15.99 50.17,15.58 50.49,15.58 50.65,15.41 50.65,12.52 51.26,11.91 51.6,11.91 51.63,11.88 51.76,11.88 51.87,11.77 51.87,10.47 51.76,10.36 50.39,10.36 50.25,10.22 47.8,10.22 47.66,10.36 47.66,11.15 48.09,11.57 48.09,12.34 47.81,12.61 47.81,17.15 47.95,17.29 49.07,17.29
+5V_HDD1 on BOTTOM (solid shape): 50.45,10.59 50.45,7.33 50.62,7.16 50.62,6.43 50.45,6.26 50.45,5.26 50.32,5.13 50.27,5.13 50.24,5.14 50.22,5.18 50.22,6.25 49.98,6.25 49.98,5.18 49.96,5.14 49.93,5.13 49.77,5.13 49.74,5.14 49.72,5.18 49.72,6.25 49.48,6.25 49.48,5.18 49.46,5.14 49.43,5.13 49.27,5.13 49.24,5.14 49.22,5.18 49.22,6.25 48.98,6.25 48.98,5.18 48.96,5.14 48.93,5.13 48.77,5.13 48.77,7.94 48.67,8.05 48.67,10.44 48.87,10.64 50.4,10.64
+5V_KB on TOP (solid shape): 121.57,12.55 121.57,8.93 121.56,8.89 121.52,8.88 120.96,8.88 120.47,8.4 120.36,8.37 120.3,8.47 120.3,9.57 120.05,9.83 118.37,9.83 118.34,9.84 118.32,9.88 118.32,9.93 117.79,9.93 117.76,9.96 117.76,10.22 118.01,10.47 118.6,10.47 120.8,12.67 121.44,12.67
+5V_KB on BOTTOM (solid shape): 118.78,12.37 118.78,10.21 118.65,10.08 117.38,10.08 117.25,10.21 117.25,11.67 117.38,11.8 117.38,12.37 117.4,12.4 117.43,12.42 117.71,12.42 117.85,12.44 117.98,12.5 118.65,12.5
+5V_PVDD on TOP (solid shape): outline of 91 points within 170.72,14.83 176.48,18.66
+5V_S5 on TOP (solid shape): 93.55,91.95 93.55,90.4 92.87,89.71 92.87,89.68 92.79,89.61 92.79,89.13 92.74,89.08 90.94,89.08 90.84,89.18 90.84,91.49 91.47,92.12 93.38,92.12
+5V_S5 on TOP (solid shape): 165.48,57.17 165.85,57 166.24,57.13 166.28,57.14 166.31,57.13 166.4,57.07 166.49,57.03 166.51,57.02 166.53,57 166.53,54.15 166.4,54.02 166.12,54.02 165.32,54.82 164.12,54.82 163.91,54.61 161.98,54.61 161.89,54.7 161.89,55.99 161.96,56.06 162.72,56.06 162.85,55.93 162.85,55.55 162.97,55.42 165.01,55.42 165.13,55.55 165.13,57.03 165.14,57.05 165.16,57.07 165.23,57.12 165.3,57.17 165.32,57.2 165.45,57.2
+5V_S5 on TOP (solid shape): 116.75,94.79 116.75,91.74 116.62,91.62 114.97,91.62 114.84,91.74 114.84,92.94 114.84,93.01 114.33,93.52 114.33,94.28 114.71,94.28 114.72,94.23 114.73,94.17 114.75,94.12 114.78,94.07 114.81,94.03 114.85,93.99 114.89,93.96 114.94,93.93 115,93.91 115.05,93.9 115.11,93.9 115.16,93.91 115.22,93.92 115.27,93.94 115.32,93.97 115.36,94.01 115.4,94.05 115.43,94.1 115.45,94.15 115.47,94.2 115.48,94.26 115.48,94.31 115.47,94.37 115.45,94.42 115.43,94.47 115.4,94.52 115.36,94.56 115.32,94.59 115.27,94.62 115.22,94.64 115.16,94.66 115.11,94.66 115.05,94.66 115,94.65 114.94,94.63 114.89,94.61 114.85,94.58 114.81,94.54 114.78,94.49 114.75,94.45 114.73,94.39 114.72,94.34 114.71,94.28 114.33,94.28 114.33,94.79 114.46,94.92 116.62,94.92
+5V_S5 on TOP (solid shape): 161.96,13.71 161.96,6.53 161.45,6.02 159.04,6.02 158.78,5.76 158.78,5.51 158.66,5.38 157.89,5.38 157.77,5.51 157.77,5.88 157.64,6.01 156.84,6.01 156.5,6.35 156.5,6.53 156.49,6.55 156.43,6.7 156.29,6.77 156.27,6.78 156.24,6.8 156.24,7.16 156.26,7.19 156.29,7.21 156.31,7.21 156.31,7.99 156.37,8.05 156.46,8.05 156.49,8.04 156.51,8 156.51,7.21 156.71,7.21 156.71,8 156.72,8.04 156.76,8.05 157.36,8.05 157.61,7.8 158.25,7.8 158.55,8.1 159.65,8.1 159.72,8.18 159.72,9.4 159.54,9.57 159.54,12.59 159.54,12.59 159.54,13.44 160.09,13.98 161.69,13.98
+5V_S5 on BOTTOM (solid shape): 116.82,94.64 116.82,91.44 116.75,91.36 115.73,91.36 115.6,91.49 115.6,94.71 115.63,94.74 116.72,94.74
+5V_S5 on BOTTOM (solid shape): 165.38,57.19 165.39,57.18 165.63,57 165.92,56.95 166,56.92 166.03,56.84 166.03,56.8 166.53,56.3 166.53,55.04 166.4,54.91 164.62,54.91 164.5,55.04 164.5,55.29 164.62,55.42 165.01,55.42 165.13,55.55 165.13,57.07 165.26,57.2 165.36,57.2
+5V_S5 on BOTTOM (solid shape): 145.33,29.51 145.41,29.48 145.43,29.41 145.43,29.39 145.43,27.68 145.42,27.64 145.38,27.63 145.05,27.63 144.94,27.74 144.94,28.12 145.07,28.24 145.07,28.35 145.07,28.36 145.09,28.49 145.07,28.62 145.07,28.63 145.07,28.75 144.94,28.88 144.3,28.88 143.67,28.24 143.67,27.74 143.56,27.63 143.02,27.63 142.91,27.74 142.91,28.37 144.05,29.51
+5V_S5 on SVCC (solid shape): outline of 948 points within 88.3,9.96 184.97,104.06
+5V_S5 on IN2 (solid shape): outline of 628 points within 91.09,87.43 116.8,94.97
+5VA on TOP (solid shape): 183.55,29.01 183.55,24.56 183.29,24.31 183.28,24.28 183.17,23.92 183.29,23.56 183.29,23.15 183.18,22.89 183.2,22.6 183.2,22.59 183.2,22.56 183.17,22.53 182.91,22.53 182.79,22.66 182.79,23.04 182.89,23.29 182.79,23.54 182.79,24.81 181.77,25.83 181.77,27.61 180.63,28.75 175.93,28.75 174.78,27.61 173.9,27.61 173.77,27.74 173.77,30.53 173.9,30.66 175.04,30.66 175.67,30.02 175.8,30.02 175.81,30.01 176.28,29.9 176.69,30.15 176.69,30.15 176.94,30.4 176.94,31.37 176.96,31.4 176.99,31.42 181.13,31.42
+5VPCU on TOP (solid shape): outline of 86 points within 151.08,9.32 159.16,17.63
+5VPCU on BOTTOM (solid shape): 160.64,19.3 160.64,14.32 160.51,14.2 156.93,14.2 156.24,14.88 156.24,16.69 156.34,16.79 157.69,16.79 157.77,16.86 157.77,17.58 157.78,17.59 157.78,18.24 157.79,18.24 157.79,18.43 157.94,18.59 159.34,18.59 159.54,18.79 159.54,19.28 159.62,19.35 160.59,19.35
+5VPCU on IN3 (solid shape): outline of 300 points within 163.3,56.21 169.32,65.58
+12V_PANEL on TOP (solid shape): 169.91,73.84 169.94,73.82 169.96,73.79 169.96,73.04 170.09,72.92 170.09,72.44 170.21,72.31 172.19,72.31 172.21,72.31 172.33,72.22 172.45,72.19 172.49,72.17 172.5,72.14 172.5,69.77 172.37,69.65 168.56,69.65 168.43,69.77 168.43,73.71 168.56,73.84
+V3A_LX on BOTTOM (solid shape): 157.89,51.36 157.89,50.6 158.15,50.34 158.91,50.34 159.16,50.09 159.16,49.02 158.27,48.13 158.27,47.12 157.16,47.12 157.03,47.24 157.03,48.66 156.88,48.82 156.73,48.82 155.98,49.57 154.07,49.57 153.88,49.76 153.88,51.48 154.01,51.61 157.64,51.61
+V3A_OUT on TOP (solid shape): 153.58,57.96 153.58,55.17 152.43,54.02 152.43,53.52 152.31,53.39 151.16,53.39 151.04,53.52 151.04,57.96 151.16,58.09 153.45,58.09
+V3A_OUT on BOTTOM (solid shape): 153.32,61.19 153.32,60.47 153.32,60.42 153.88,59.87 157.64,59.87 157.77,59.74 157.77,56.28 157.72,56.23 157.7,56.22 157.38,55.84 157.72,55.47 157.75,55.45 157.77,55.42 157.77,53.39 157.39,53.01 152.14,53.01 152.11,53.01 151.88,53.01 151.86,53.01 151.29,53.01 151.16,53.14 151.16,56.95 151.29,57.07 151.82,57.07 152.94,58.19 152.94,61.14 153.05,61.24 153.26,61.24
+V3A_VIN on BOTTOM (solid shape): 157.33,46.86 157.33,44.6 157.5,44.44 157.5,40.35 157.89,39.95 157.89,38.4 157.77,38.28 153.91,38.28 153.83,38.35 153.83,38.45 153.84,38.47 153.91,38.69 153.83,38.91 153.83,40.69 153.96,40.82 154.34,40.82 154.62,41.1 154.62,41.81 154.94,42.14 154.99,42.17 155.03,42.22 155.11,42.3 155.11,43.24 155.28,43.41 155.56,43.41 156.45,44.3 156.67,44.3 156.8,44.42 156.8,46.84 156.88,46.91 157.28,46.91
+V5P5A_LX on BOTTOM (solid shape): 163.07,30.43 163.07,29.26 163.17,29.26 163.21,29.24 163.22,29.21 163.22,29.14 163.71,29.14 163.71,29.21 163.72,29.24 163.76,29.26 164.5,29.26 165.89,27.86 165.89,26.72 165.59,26.41 160.1,26.41 159.77,26.74 159.77,30.02 159.87,30.12 160.89,30.12 161.42,30.66 162.05,30.66 162.05,30.65 162.54,30.65 162.54,30.66 162.85,30.66
+V5P5A_OUT on TOP (solid shape): 164.5,19.23 164.5,14.53 164.37,14.4 163.74,14.4 162.85,15.29 162.85,19.23 162.97,19.35 164.37,19.35
+V5P5A_OUT on BOTTOM (solid shape): 165.56,21.5 165.56,20.34 164.83,19.61 164.62,19.61 164.5,19.48 164.5,19.44 164.48,19.43 164.48,18.72 164.5,18.7 164.5,14.4 164.37,14.27 161.45,14.27 161.33,14.39 161.33,19.49 160.42,20.41 160.42,22.06 160.75,22.39 164.67,22.39
+V5P5A_VIN on TOP (solid shape): 162.59,35.99 162.59,33.45 162.47,33.32 161.58,33.32 161.45,33.45 161.45,35.99 161.58,36.12 162.47,36.12
+V5P5A_VIN on BOTTOM (solid shape): outline of 155 points within 162.08,30.81 167.33,41.58
+VCC_VCCGI on TOP (solid shape): 87.38,83.87 87.38,82.93 86.77,82.32 80.7,82.32 80.04,82.98 79.66,82.98 79.53,83.11 79.53,83.36 80.3,84.12 87.13,84.12
+VCC_VCCGI on TOP (solid shape): 67.22,83.74 77.07,83.74 77.22,83.59 77.22,82.98 76.97,82.73 76.55,82.73 76.46,82.76 76.35,82.78 76.05,82.63 75.98,82.3 75.98,82.29 75.98,79.81 75.85,79.68 66.1,79.68 65.69,80.08 65.69,84.25 65.82,84.38 66.58,84.38
+VCC_VCCGI on TOP (solid shape): outline of 201 points within 94.34,60.96 98.51,71.96
+VCC_VCCGI on TOP (solid shape): outline of 336 points within 77.83,72.19 89.44,81.33
+VCC_VCCGI on BOTTOM (solid shape): 87.41,79.68 87.41,79.04 87.76,78.69 87.76,77.33 87.96,77.13 87.98,77.09 87.96,77.06 86.77,75.87 85.88,75.87 85,76.76 85,77.1 85.07,77.32 85,77.54 85,78.03 84.74,78.28 83.46,78.28 83.39,78.31 83.35,78.38 83.09,78.71 82.69,78.55 82.67,78.53 82.65,78.52 81.32,78.52 81.19,78.66 80.17,78.66 80.04,78.79 80.04,79.5 80.35,79.81 87.28,79.81
+VCC_VCCGI on BOTTOM (solid shape): 84.4,84.5 84.54,84.47 84.69,84.5 84.7,84.5 87.12,84.5 87.26,84.36 87.26,82.45 87.15,82.35 78.53,82.35 78.47,82.41 77.42,82.41 77.42,82.41 77.23,82.41 76.87,82.78 76.81,82.85 76.74,82.91 76.61,83.03 76.08,83.03 75.71,82.66 75.71,82.13 75.72,82.12 75.72,81.24 75.33,80.85 75.33,80.81 75.19,80.67 75.19,79.98 75.15,79.94 75.17,79.93 75.17,79.78 75.04,79.65 74.99,79.66 74.68,79.66 74.65,79.65 67.32,79.65 66.33,78.66 63.41,78.66 63.28,78.54 60.87,78.54 60.74,78.66 60.74,83.74 60.84,83.84 63.2,83.84 63.74,84.38 69.42,84.38 70.06,83.74 75.6,83.74 75.93,84.07 76,84.07 76,84.07 76.19,84.26 77.11,84.26 77.12,84.24 78.57,84.24 78.57,84.2 78.75,83.89 79.09,83.8 79.1,83.78 80.73,83.78 80.94,84 81.31,84 81.82,84.5 84.39,84.5
+VCC_VCCGI on BOTTOM (solid shape): outline of 271 points within 93.76,60.4 98.08,68.86
+VCC_VCCGI on IN1 (solid shape): outline of 184 points within 93.99,62.34 98.61,68.88
+VCC_VCCGI on SVCC (solid shape): outline of 337 points within 65.95,60.5 106.96,84.38
+VCC_VCCGI on IN2 (solid shape): outline of 4461 points within 66.14,65.58 98.2,84.25
+VCCDDQ on TOP (solid shape): outline of 3580 points within 84.56,39.14 109.56,59.96
+VCCDDQ on IN2 (solid shape): outline of 100 points within 89.19,56.18 96.17,60.53
+VCCIOA on TOP (solid shape): 84.16,56.79 84.16,55.99 84.88,55.27 84.88,54.11 84.72,53.95 82.3,53.95 82.25,54 82.25,56.34 82.86,56.95 84,56.95
+VCCIOA on TOP (solid shape): 97.95,60.76 100.74,60.76 100.82,60.68 100.82,59.89 100.74,59.82 99.47,59.82 99.09,59.43 96.63,59.43 96.37,59.69 96.37,59.71 96.3,59.83 96.18,59.89 96.17,59.89 96.09,59.97 95.36,59.97 95.12,60.05 94.88,59.97 94.67,59.97 94.62,60.02 94.62,60.48 94.72,60.58 96.73,60.58 96.96,60.81 97.9,60.81
+VCCIOA on BOTTOM (solid shape): 99.51,60.1 99.51,59.21 99.33,59.03 99.06,59.03 98.78,59.13 98.5,59.03 97.03,59.03 96.83,59.08 96.62,59.03 96.25,59.03 96.1,59.18 96.1,60.1 96.19,60.19 96.5,60.19 96.79,59.89 96.83,59.84 96.87,59.81 96.91,59.77 97.14,59.77 97.32,59.94 97.5,59.94 97.55,59.89 97.59,59.84 97.64,59.81 97.69,59.75 97.71,59.75 97.75,59.72 98.59,59.72 98.68,59.8 98.73,59.84 98.77,59.9 99.12,60.25 99.35,60.25
+VCCIOA on IN1 (solid shape): outline of 1849 points within 82.89,55.34 99.17,60.42
+VCCRAM_1P05 on TOP (solid shape): 125,78.15 125,75.69 124.91,75.6 124.63,75.6 124.47,75.44 124.41,75.44 122.64,73.67 122.64,73.61 121.67,73.61 121.44,73.84 121.44,74.37 121.53,74.45 121.63,74.45 122.15,74.97 122.23,75.07 122.27,75.2 122.28,75.21 122.43,75.21 122.6,75.37 122.6,75.51 122.61,75.52 122.66,75.74 122.6,75.95 122.6,76.29 122.66,76.51 122.6,76.73 122.6,77.53 122.73,77.66 122.76,77.67 123.12,77.67 123.12,77.67 123.25,77.65 123.38,77.67 123.39,77.67 123.75,77.67 123.76,77.67 123.89,77.65 124.02,77.67 124.03,77.67 124.14,77.67 124.24,77.77 124.24,77.87 124.24,77.88 124.27,78.03 124.24,78.17 124.24,78.18 124.24,78.28 124.37,78.41 124.75,78.41
+VCCRAM_1P05 on TOP (solid shape): outline of 388 points within 88.81,63.04 95.21,67.61
+VCCRAM_1P05 on BOTTOM (solid shape): 123.76,76.17 123.76,74.7 122.76,73.71 121.88,73.71 121.42,74.17 121.42,76.1 121.57,76.25 123.68,76.25
+VCCRAM_1P05 on BOTTOM (solid shape): 93.22,66.68 93.23,66.67 93.55,66.47 93.9,66.6 93.97,66.63 94.04,66.6 94.14,66.53 94.25,66.49 94.26,66.48 94.4,66.35 94.4,65.66 94.7,65.36 94.7,65.35 95.05,65.04 95.48,65.23 95.49,65.24 95.51,65.25 95.57,65.25 95.64,65.18 95.64,65.03 95.64,65.01 95.63,64.99 95.52,64.74 95.63,64.48 95.64,64.45 95.64,64.4 95.64,64.38 95.62,64.36 95.52,64.25 95.45,64.11 95.45,64.09 95.39,64.03 94.53,64.03 94.17,63.68 94.1,63.64 94.04,63.59 93.97,63.56 93.59,63.72 93.28,63.59 93.27,63.58 93.25,63.57 93.13,63.57 93.03,63.68 93.03,66.62 93.1,66.7 93.18,66.7
+VCCRAM_1P05 on IN2 (solid shape): outline of 5408 points within 93.17,61.42 123.6,80.69
+VCCRAM_1P05 on IN3 (solid shape): outline of 320 points within 92.62,63.81 98.58,66.72
+VDD1_1P8 on TOP (solid shape): 100.74,70.92 100.74,70.15 100.18,69.59 100.18,68.83 100.1,68.75 100.1,68.41 100.19,68.13 100.45,68.01 100.74,68.01 100.74,68 100.74,67.6 100.62,67.25 100.72,66.88 100.72,66.85 100.71,66.82 100.62,66.72 99.02,66.72 98.91,66.83 98.91,68.17 98.94,68.2 99.1,68.2 99.14,68.21 99.19,68.22 99.22,68.22 99.35,68.35 99.35,69.12 99.64,69.42 99.64,70.06 100.01,70.43 100.01,70.97 100.08,71.04 100.62,71.04
+VDD1_1P8 on BOTTOM (solid shape): 100.13,68.17 100.15,68.17 100.17,68.15 100.45,68.01 100.74,68.15 100.76,68.17 100.78,68.17 100.9,68.17 101,68.07 101,67.11 100.52,66.62 100.36,66.62 100.31,66.65 100.28,66.71 100.24,66.75 99.88,67.11 99.17,67.11 99.1,67.18 99.1,68.1 99.17,68.17
+VDD1_1P8 on IN3 (solid shape): 100.7,68.1 100.73,68.1 100.75,68.09 101.07,67.77 101.07,67.61 100.45,66.99 100.45,66.65 100.44,66.61 100.4,66.6 100.36,66.6 100.3,66.54 100.3,66.54 100.18,66.46 100.1,66.34 100.1,66.33 99.93,66.17 99.93,65.41 99.81,65.29 99.81,62.56 99.8,62.49 99.76,62.47 99.41,62.47 99.34,62.5 99.3,62.57 99.29,62.65 99.26,62.74 99.26,63.23 99.24,63.24 99.24,63.81 99.3,64.01 99.24,64.22 99.24,65.26 99.3,65.46 99.24,65.67 99.24,65.98 99.3,66.19 99.24,66.39 99.24,67.12 99.26,67.19 99.27,67.26 99.27,67.85 99.3,67.85 99.96,67.85 100.18,68.07 100.2,68.08 100.23,68.08 100.25,68.07 100.47,68.01 100.67,68.09
+VDD2_1P24_MPHY on TOP (solid shape): 101,64.95 102.12,64.95 102.77,64.29 102.8,64.29 102.9,64.18 102.9,63.93 102.78,63.8 101.12,63.8 101,63.93 100.24,63.93 100.11,64.06 100.11,65.33 100.24,65.45 100.49,65.45
+VDD2_1P24_MPHY on TOP (solid shape): 114.23,67.05 114.23,66.02 114.22,65.99 114.18,65.97 113.32,65.97 113.32,65.89 113.3,65.85 113.26,65.84 108.87,65.84 108.74,65.96 108.74,66.98 108.87,67.11 112.55,67.11 113.19,67.74 113.54,67.74
+VDD2_1P24_MPHY on BOTTOM (solid shape): 101.35,64.98 101.35,64.98 101.59,64.83 101.82,64.97 101.83,64.98 101.86,65 102.07,65 102.2,64.87 102.2,64.62 102.19,64.6 102.18,64.58 102.08,64.38 102.18,64.17 102.19,64.15 102.2,64.13 102.2,63.93 101.98,63.72 101.96,63.72 101.71,63.63 101.56,63.41 101.55,63.39 101.53,63.37 100.75,63.37 100.62,63.5 100.62,65.2 100.72,65.3 101.03,65.3
+VDD2_1P24_MPHY on IN1 (solid shape): outline of 949 points within 100.9,61.09 112.4,66.34
+VDD2_1P24_PLL on TOP (solid shape): outline of 308 points within 101.76,60.37 113.32,62.61
+VDD2_1P24_VNNAON on TOP (solid shape): outline of 153 points within 101.76,64.95 106.71,66.34
+VDDQ_VTT on TOP (solid shape): 112.81,19.1 115.22,19.1 115.35,18.97 115.35,17.7 115.22,17.58 111.92,17.58 111.54,17.96 111.54,19.35 111.67,19.48 112.43,19.48
+VDDQ_VTT on TOP (solid shape): outline of 421 points within 143.7,42.59 154.2,49.31
+VDDQ_VTT on TOP (solid shape): outline of 230 points within 135.54,42.7 147.3,50.09
+VDDQ_VTT on BOTTOM (solid shape): 151.02,44.21 151.02,44.14 151.11,44.05 151.11,43.81 150.78,43.48 150.78,42.8 150.58,42.59 150.27,42.59 150.07,42.8 150.07,43.68 150.66,44.27 150.96,44.27
+VDDQ_VTT on BOTTOM (solid shape): 151.52,47.09 151.52,46.12 151.95,45.69 151.95,45.48 151.92,45.45 151.9,45.45 151.67,45.22 151.48,45.22 150.91,45.79 150.91,46.19 150.97,46.32 150.98,46.45 150.98,46.77 150.63,47.12 150.63,47.37 150.68,47.42 151.19,47.42
+VDDQ_VTT on BOTTOM (solid shape): 113.65,20.92 113.65,19.19 113.67,19.19 113.7,19.16 113.7,19.1 113.82,18.97 115.09,18.97 115.22,18.85 115.22,18.59 115.09,18.46 113.44,18.46 113.32,18.59 113.32,19.14 113.33,19.18 113.37,19.19 113.4,19.19 113.4,20.96 113.44,21 113.57,21
+VDDQ_VTT on BOTTOM (solid shape): 147.23,23.29 147.23,21.13 147.1,21 145.83,21 145.07,21.77 145.07,22.05 145.1,22.08 145.11,22.08 145.11,23.11 145.13,23.15 145.16,23.16 145.26,23.16 145.3,23.15 145.31,23.11 145.31,22.08 145.36,22.08 145.39,22.07 145.41,22.03 145.41,21.98 145.82,21.98 145.82,23.4 145.83,23.42 147.1,23.42
+VDDQ_VTT on BOTTOM (solid shape): 151.61,49.06 151.62,49.03 151.61,49.02 151.69,48.68 151.98,48.5 152,48.49 152.37,48.12 152.42,48.08 152.44,48.06 152.44,48.04 152.44,47.81 152.31,47.67 151.85,47.67 151.38,48.14 151.37,48.16 151.32,48.24 151.24,48.29 151.23,48.29 150.76,48.77 150.76,49.1 150.91,49.25 151.42,49.25
+VDDQ_VTT on IN1 (solid shape): outline of 577 points within 114.08,16.86 147.38,23.37
+VDDQ_VTT on IN2 (solid shape): outline of 1363 points within 145.96,21.64 152.81,49.2
+VIN on TOP (solid shape): 149.97,71.68 150,71.66 150.02,71.63 150.06,71.51 150.14,71.39 150.15,71.37 150.15,69.9 150.02,69.77 146.08,69.77 145.96,69.9 145.96,71.42 146.21,71.68
+VIN on TOP (solid shape): 177.71,72.64 177.71,70.53 177.58,70.41 177.32,70.41 176.82,69.9 176.31,69.9 176.18,70.03 176.18,70.92 176.05,71.04 172.88,71.04 172.75,71.17 172.75,72.26 172.76,72.28 172.77,72.3 172.81,72.34 172.84,72.4 172.88,72.44 176.56,72.44 176.94,72.82 177.53,72.82
+VIN on TOP (solid shape): 45.45,81.71 45.48,81.7 45.5,81.66 45.5,78.08 45.48,78.04 45.45,78.03 30.13,78.03 30.05,77.95 30.03,77.94 29.92,77.88 29.85,77.76 29.85,77.75 29.75,77.65 29.75,77.21 29.33,76.8 29.33,71.16 29.27,71.09 26.12,71.09 25.94,71.27 25.94,77.27 29.5,80.82 32.14,80.82 35.57,80.82 36.46,81.71
+VIN on TOP (solid shape): 132.65,15.52 133.07,15.52 133.08,15.47 133.51,15.11 133.94,15.47 133.94,15.52 137.34,15.52 137.95,14.91 137.95,12.11 137.95,12.11 137.95,11.41 137.61,11.07 136.19,11.07 136.04,11.23 136.04,11.95 136,11.99 126.02,11.99 125.89,12.11 125.89,17.58 126.02,17.7 130.46,17.7
+VIN on BOTTOM (solid shape): 27.35,73.82 28.14,73.82 28.25,73.71 28.25,71.8 27.97,71.52 27.97,70.53 27.82,70.38 25.05,70.38 24.92,70.51 24.92,73.73 25.03,73.84 27.34,73.84
+VIN on BOTTOM (solid shape): 135.29,15.16 136.43,15.16 136.81,14.78 139.35,14.78 139.48,14.65 139.48,12.98 138.97,12.62 139.48,12.26 139.48,12.08 138.49,11.09 136.28,11.09 136.02,11.35 136.02,12.02 134.12,12.02 134.02,12.11 134.02,15.42 134.14,15.54 134.91,15.54
+VIN on BOTTOM (solid shape): 163.48,46.23 163.48,42.42 163.19,42.12 162.45,42.12 162.38,42.05 162.17,42.05 161.83,41.71 161.83,41.67 161.83,41.65 161.81,41.63 161.81,37.67 161.7,37.56 160.94,37.56 160.81,37.44 160.81,35.1 158.75,33.04 158.72,33.04 158.49,33.01 158.32,32.84 158.3,32.82 158.27,32.82 154.18,32.82 153.83,33.17 153.83,37.39 153.96,37.51 158.27,37.51 158.53,37.77 158.53,39.37 158.54,39.4 158.62,39.52 158.66,39.65 158.66,39.67 158.95,39.97 159.03,40 159.11,39.96 159.67,39.9 159.67,40.47 159.66,40.54 159.63,40.6 159.63,40.63 159.64,40.66 159.8,40.82 159.8,44.4 159.93,44.52 159.93,46.2 159.98,46.25 163.46,46.25
+VIN on SVCC (solid shape): outline of 969 points within 22.64,10.72 164.24,78.41
+VIN on IN2 (solid shape): outline of 6175 points within 64.68,9.83 177.83,72.82
+VIN_BLIGHT on TOP (solid shape): 171.59,81.6 171.59,81.6 171.7,81.47 171.84,81.36 172.37,80.82 172.37,76.63 172.57,76.44 172.57,76.43 172.63,76.38 174.02,76.38 176.44,73.96 176.44,73.3 176.4,73.23 176.33,73.2 176.17,73.18 176.04,73.09 176.01,73.07 175.97,73.07 175.94,73.09 175.67,73.2 175.4,73.09 175.39,73.08 175.37,73.07 170.47,73.07 170.34,73.2 170.34,78.11 170.35,78.14 170.38,78.16 170.65,78.31 170.71,78.62 170.71,78.63 170.72,78.66 171.23,79.17 171.23,80.57 170.85,80.95 170.85,80.97 170.78,81.23 170.6,81.46 170.59,81.48 170.59,81.71 170.72,81.84 171.36,81.84
+VIN_BLIGHT on BOTTOM (solid shape): 171.61,81.08 171.61,78.66 171.48,78.54 170.97,78.54 170.85,78.66 170.85,79.3 171.36,79.3 171.36,80.45 171.11,80.45 171.11,79.3 170.86,79.3 170.86,80.45 170.85,80.45 170.85,81.08 170.97,81.2 171.48,81.2
+VIN_VCC_VCGI on TOP (solid shape): 48.04,81.58 51.47,81.58 52.61,80.44 52.61,78.66 51.72,77.77 46.64,77.77 46.51,77.9 46.51,81.71 46.64,81.84 47.78,81.84
+VIN_VCC_VCGI on BOTTOM (solid shape): 52.01,81.33 52.22,81.28 52.42,81.33 53.63,81.33 53.75,81.2 53.75,79.68 52.48,78.41 52.48,73.51 52.47,73.47 52.43,73.46 47.96,73.46 47.93,73.47 47.91,73.51 47.91,81.02 48.22,81.33
+VIN_VNN on TOP (solid shape): 29.85,75.36 31.02,75.36 31.78,74.6 34.3,74.6 34.4,74.5 34.4,71.32 34.17,71.09 29.98,71.09 29.64,71.43 29.64,75.25 29.75,75.36
+VIN_VNN on BOTTOM (solid shape): 34.7,72.69 36.74,72.69 36.99,72.44 36.99,70.03 36.86,69.9 33.81,69.9 33.43,70.28 31.91,70.28 30.77,71.42 29.62,71.42 29.5,71.55 29.5,73.2 29.62,73.33 34.07,73.33
DVDD on TOP (solid shape): 162.19,43.1 163.23,43.1 163.32,43.01 163.33,42.98 163.32,42.94 163.23,42.85 162.16,42.85 161.2,41.88 161.2,41.58 161.07,41.45 159.01,41.45 158.81,41.25 158.81,41.17 158.81,41.17 158.79,41.06 158.81,40.96 158.81,40.95 158.81,39.17 158.74,39.1 157.96,39.1 157.74,39.32 157.74,40.76 157.37,41.12 157.37,42.08 157.64,42.34 159.25,42.34 159.26,42.34 159.39,42.31 159.52,42.34 159.54,42.34 159.56,42.35 159.66,42.43 159.73,42.53 159.74,42.53 159.8,42.59 160.31,42.59 160.42,42.71 160.51,42.76 160.59,42.83 160.61,42.84 160.63,42.85 161.2,42.85 161.58,43.23 162.06,43.23
DVDD_IO on TOP (solid shape): 180.46,15.38 180.5,15.39 180.53,15.38 180.58,15.33 180.58,14.39 180.6,14.39 180.63,14.36 180.63,13.77 180.88,13.51 180.88,10.48 180.88,10.46 180.69,10.22 180.63,9.96 180.63,9.75 180.62,9.72 180.58,9.7 180.5,9.7 180.37,9.83 180.37,14.39 180.38,14.39 180.38,15.3
GND on TOP (solid shape): 31.99,91.13 31.99,88.57 31.91,88.49 29.37,88.49 29.29,88.57 29.29,91.16 29.32,91.18 31.93,91.18
GND on TOP (solid shape): 35.01,66.7 35.01,64.41 34.93,64.34 32.65,64.34 32.59,64.39 32.59,66.75 32.62,66.77 34.93,66.77
GND on TOP (solid shape): 108.24,35.33 108.24,27.86 107.98,27.61 100.36,27.61 100.11,27.86 100.11,35.33 100.36,35.58 107.98,35.58
GND on TOP (solid shape): 119.62,70.41 119.62,66.98 119.11,66.47 116.14,66.47 116.03,66.57 116.03,70.61 116.14,70.71 119.31,70.71
GND on TOP (solid shape): 121.93,86.23 121.93,81.99 121.8,81.86 117.46,81.86 117.38,81.94 117.38,86.36 117.41,86.38 121.77,86.38
GND on TOP (solid shape): 166.28,19.23 166.28,14.4 166.15,14.27 164.88,14.27 164.75,14.4 164.75,19.23 164.88,19.35 166.15,19.35
GND on TOP (solid shape): 105.89,13.83 105.89,12.05 105.49,11.66 104.2,11.66 104.05,11.81 104.05,13.92 104.12,13.99 105.72,13.99
GND on TOP (solid shape): 55.28,84.12 55.28,82.85 53.63,81.2 52.23,81.2 51.59,81.84 48.42,81.84 48.29,81.96 48.29,82.73 50.45,84.89 54.52,84.89
GND on TOP (solid shape): 65.56,91.74 65.56,89.71 65.06,89.2 62.77,89.2 62.64,89.33 62.64,91.82 62.77,91.95 65.36,91.95
GND on TOP (solid shape): 88.68,16.69 88.68,10.46 88.55,10.34 87.03,10.34 86.9,10.46 86.9,16.69 87.03,16.81 88.55,16.81
GND on TOP (solid shape): 150.78,57.96 150.78,53.26 150.65,53.14 150.02,53.14 149.89,53.26 149.89,55.17 148.62,56.44 148.62,57.96 148.75,58.09 150.65,58.09
GND on TOP (solid shape): 173.01,27.04 173.01,26.95 172.66,26.59 172.58,26.59 172.08,26.09 171.94,26.09 171.77,26.27 171.77,26.37 172.49,27.08 172.97,27.08
GND on TOP (solid shape): 133.76,30.12 133.76,29.25 133.76,29.21 133.74,29.16 133.61,29.03 132.92,29.03 132.24,29.72 132.24,30.12 132.32,30.2 133.69,30.2
GND on TOP (solid shape): 89.52,89.53 89.52,88.77 89.49,88.75 89.36,88.75 89.36,88.74 88.37,88.74 88.35,88.72 86.39,88.72 86.16,88.95 86.16,89.43 86.29,89.56 89.49,89.56
GND on TOP (solid shape): 110.72,93.01 112.73,93.01 114.59,93.01 114.71,92.89 114.71,89.74 112.78,87.81 108.24,87.81 107.98,88.06 107.98,92.76 108.24,93.01 110.72,93.01
GND on TOP (solid shape): 153.32,68.38 153.32,68.14 153.32,65.05 153.32,64.82 153.19,64.69 152.18,64.69 152.05,64.82 152.05,68.38 152.18,68.5 153.19,68.5
GND on TOP (solid shape): 153.55,21.39 154.2,20.73 154.25,20.73 154.26,20.72 155.76,20.72 155.86,20.62 155.86,19.53 155.81,19.48 147.3,19.48 147.23,19.56 147.23,21.28 147.43,21.49 153.45,21.49
GND on TOP (solid shape): 170.21,69.14 170.21,67.36 170.09,67.23 169.07,67.23 168.82,66.98 163.99,66.98 163.86,67.11 163.86,67.99 163.99,68.12 167.16,68.12 168.31,69.26 170.09,69.26
GND on TOP (solid shape): 33.57,99.71 33.57,95.87 32.44,94.74 31.5,94.74 31.32,94.92 31.32,96.9 30.77,97.46 28.71,97.46 27.83,98.33 26.08,98.33 25.94,98.47 25.94,99.87 26.07,100 33.28,100
GND on TOP (solid shape): 111.81,63.98 114.03,63.98 114.08,63.93 114.08,62.66 114.05,62.63 112.15,62.63 111.87,62.91 111.41,62.91 110.9,63.42 109.38,63.42 109.25,63.55 109.25,63.97 109.46,64.18 111.61,64.18
GND on TOP (solid shape): 123.98,12.5 123.98,10.21 123.86,10.08 121.83,10.08 121.77,10.13 121.77,10.21 121.75,10.21 121.71,10.22 121.7,10.26 121.7,12.5 121.83,12.62 123.86,12.62
GND on TOP (solid shape): 130.46,76.12 130.46,75.54 130.2,75.28 125.59,75.28 125.55,75.33 125.51,75.36 125.13,75.74 125.13,78.23 125.14,78.27 125.18,78.28 128.3,78.28
GND on TOP (solid shape): 70.52,58.22 70.52,57.2 70.64,57.07 71.03,57.07 71.15,56.95 71.15,54.79 71.03,54.66 69.76,54.66 69.5,54.91 69.5,58.22 69.63,58.34 70.39,58.34
GND on TOP (solid shape): 58.43,56.21 58.43,55.7 59.04,55.09 59.25,55.09 59.41,54.94 59.41,52.59 59.29,52.47 58.08,52.47 57.9,52.65 57.9,54 57.92,54.02 58,54.02 58,54.09 58.02,54.12 58.02,54.91 57.69,55.24 57.69,56.13 57.82,56.26 58.38,56.26
GND on TOP (solid shape): 159.29,79.04 159.29,78.41 158.91,78.03 158.15,78.03 157.89,78.28 156.5,78.28 156.37,78.41 156.37,78.92 156.5,79.04 157.64,79.04 157.81,79.22 157.83,79.22 157.83,79.24 158.02,79.42 158.02,79.42 158.15,79.55 158.78,79.55
GND on TOP (solid shape): 34.96,87.4 34.96,84.73 35.08,84.61 35.69,84.61 35.82,84.48 35.82,83.92 35.81,83.88 35.77,83.87 35.54,83.87 35.18,83.51 34.04,83.51 33.81,83.74 33.81,85.44 33.84,85.47 33.84,87.4 33.94,87.5 34.86,87.5
GND on TOP (solid shape): 63.77,8.57 63.77,7.31 63.78,7.3 63.78,7.28 63.8,7.28 64.23,6.85 64.23,6.43 64.1,6.3 61.08,6.3 61,6.38 61,6.6 61,6.6 61,7.81 61.28,8.09 62.84,8.09 63.36,8.6 63.74,8.6
GND on TOP (solid shape): 161.2,36.23 161.2,33.32 161.32,33.2 161.52,33.2 161.52,33.2 162.52,33.2 162.72,33.2 162.8,33.12 162.8,29.49 162.64,29.34 160.64,29.34 160.37,29.6 160.37,30.99 160.38,31 160.38,32.4 160.22,32.56 160.22,33.48 160.58,33.84 160.58,34.31 160.69,34.42 160.69,36.22 160.79,36.32 161.11,36.32
GND on TOP (solid shape): 102.34,15.24 102.34,14.25 102.52,14.07 103.49,14.07 103.61,13.94 103.61,11.81 103.46,11.66 100.64,11.66 100.51,11.78 100.51,13.18 100.47,13.23 100.47,13.28 100.4,13.44 100.24,13.51 100.19,13.51 100.08,13.61 100.08,13.94 100.24,14.1 100.9,14.1 101.02,14.22 101.02,15.21 101.1,15.29 102.29,15.29
GND on TOP (solid shape): 68.68,60.02 68.72,59.95 68.78,59.91 69.05,59.64 69.07,59.62 69.07,59.6 69.07,57.78 68.99,57.71 66.76,57.71 66.73,57.73 66.73,58.37 67.29,58.93 68.46,58.93 68.54,59 68.54,59.46 68.47,59.52 68.46,59.53 68.37,59.68 68.23,59.77 68.22,59.77 67.94,60.05 67.94,60.36 67.99,60.41 68.28,60.41
GND on TOP (solid shape): 47.43,14.92 47.43,12.49 47.3,12.34 47.28,12.14 47.21,12.01 47.2,11.86 47.2,10.47 47.05,10.31 45.17,10.31 45.04,10.44 45.04,10.92 45.38,11.26 45.38,11.41 45.5,11.53 45.5,14.4 45.63,14.53 45.65,14.53 46.11,14.98 46.15,15.02 46.26,15.13 47.21,15.13
GND on TOP (solid shape): 82.56,64.92 82.56,64.16 82.58,64.13 82.58,61.7 82.43,61.54 81.67,61.54 81.52,61.69 81.52,61.92 81.31,62.13 80.63,62.13 80.55,62.2 80.55,62.66 80.68,62.79 81.44,62.79 81.57,62.91 81.57,63.24 81.62,63.31 81.65,63.4 81.65,63.7 81.62,63.79 81.57,63.86 81.57,64.95 81.69,65.07 82.4,65.07
GND on TOP (solid shape): 96.88,74.78 96.88,74.3 97.57,73.61 97.57,73.18 97.47,73.07 97.19,73.07 97.06,72.95 97.06,72.93 97.03,72.87 97.01,72.82 96.99,72.77 96.99,72.72 96.99,72.44 97,72.37 97.06,72.28 97.06,72.27 97.06,72.06 96.93,71.93 96.55,71.93 96.43,72.06 96.43,73.17 96.53,73.27 96.53,73.89 96.43,74 96.43,74.73 96.55,74.85 96.81,74.85
GND on TOP (solid shape): 159.54,9.39 159.54,8.38 159.52,8.35 158.53,8.35 158.1,7.92 157.72,7.92 157.46,8.18 156.93,8.18 156.32,8.18 156.32,8.18 154.77,8.18 154.77,8.18 154.28,8.18 154.21,8.18 153.96,7.92 151.67,7.92 151.54,8.05 151.54,8.86 152.13,9.45 153.7,9.45 153.96,9.19 154.28,9.19 154.9,9.19 156.32,9.19 156.93,9.19 157.26,9.19 157.51,9.45 158.15,9.45 158.4,9.7 159.24,9.7
GND on TOP (solid shape): 103.42,91.42 103.42,91.18 103.52,91.09 103.52,90.49 103.7,90.31 103.7,89.64 103.7,89.32 104.05,89.32 104.05,87.55 104.3,87.3 104.3,86.92 104.2,86.82 103.38,86.82 103.11,87.09 103.11,87.11 102.9,87.31 102.9,87.52 102.91,87.52 102.91,88.33 102.89,88.33 102.78,88.44 102.65,88.44 102.52,88.57 102.52,89.32 103.31,89.32 103.31,90.13 102.9,90.13 102.9,89.32 102.52,89.32 102.52,90.97 102.59,91.04 102.61,91.06 102.66,91.09 102.69,91.12 102.72,91.16 102.75,91.21 102.77,91.25 102.78,91.3 102.78,91.36 102.79,91.42 102.8,91.45 102.82,91.47 102.84,91.48 102.88,91.49 103.35,91.49
GND on TOP (solid shape): 48.17,70.79 48.17,69.65 48.04,69.52 48.04,69.5 48.03,69.48 48.02,69.47 47.94,69.39 47.91,69.29 47.91,69.15 47.91,69.01 47.94,68.9 48.02,68.82 48.03,68.81 48.04,68.79 48.04,68.72 48.03,68.7 48.02,68.7 47.94,68.61 47.91,68.51 47.91,68.23 47.94,68.12 48.02,68.04 48.03,68.03 48.04,68.01 48.04,65.45 48,65.42 46.42,65.42 46.26,65.58 46.26,70.79 46.39,70.92 48.04,70.92
GND on TOP (solid shape): 104.45,67.51 104.45,67.23 104.68,67 104.68,66.98 104.75,66.82 104.91,66.75 105.19,66.75 105.35,66.82 105.42,66.98 105.42,67.36 105.57,67.51 106.33,67.51 106.41,67.44 106.41,66.32 106.28,66.19 104.58,66.19 104.37,66.4 104.36,66.42 104.36,66.44 104.27,66.7 104.04,66.83 104.02,66.83 103.82,67.03 103.82,67.54 103.87,67.59 104.38,67.59
GND on TOP (solid shape): 112.3,13 112.3,10.59 112.43,10.46 114.33,10.46 114.59,10.72 114.59,11.48 114.71,11.61 118.27,11.61 118.4,11.48 118.4,11.17 118.33,11.1 117.74,11.1 117.61,10.97 117.51,10.97 117.38,10.84 117.38,10.74 116.17,9.53 116.17,8.74 116.16,8.7 116.12,8.69 115.73,8.69 115.6,8.81 115.6,9.7 115.48,9.83 115.46,9.83 115.43,9.85 115.43,9.87 115.06,10.15 114.69,9.87 114.67,9.84 114.64,9.83 111.54,9.83 111.41,9.96 111.41,11.99 111.16,12.24 111.16,13 111.28,13.13 112.17,13.13
GND on TOP (solid shape): 160.43,47.95 160.43,44.88 160.31,44.75 159.93,44.75 159.67,44.5 159.44,44.5 159.29,44.5 159.25,44.46 159.25,44.46 159.15,44.39 159.08,44.29 159.07,44.28 159.04,44.25 159.04,43.38 159.21,43.04 159.58,43.01 159.61,43.02 159.64,43 159.67,42.98 159.67,42.67 159.47,42.47 158.09,42.47 158.02,42.47 156.4,42.47 156.22,42.64 156.22,43.64 156.57,43.99 157.77,43.99 158.02,44.25 158.02,47.42 158.91,48.31 160.08,48.31
GND on TOP (solid shape): 34.54,77.51 34.54,74.99 34.4,74.85 31.78,74.85 31.32,75.31 31.32,75.56 29.65,75.56 29.55,75.66 29.55,76.63 29.58,76.66 33.38,76.66 33.38,76.6 33.39,76.54 33.4,76.49 33.43,76.43 33.46,76.38 33.49,76.33 33.54,76.29 33.59,76.26 33.64,76.23 33.69,76.21 33.75,76.2 33.81,76.2 33.87,76.2 33.93,76.21 33.98,76.23 34.04,76.26 34.08,76.29 34.13,76.33 34.16,76.38 34.2,76.43 34.22,76.49 34.23,76.54 34.24,76.6 34.24,76.66 34.23,76.72 34.22,76.77 34.2,76.83 34.16,76.88 34.13,76.93 34.08,76.97 34.04,77 33.98,77.03 33.93,77.05 33.87,77.06 33.81,77.06 33.75,77.06 33.69,77.05 33.64,77.03 33.59,77 33.54,76.97 33.49,76.93 33.46,76.88 33.43,76.83 33.4,76.77 33.39,76.72 33.38,76.66 29.58,76.66 29.95,77.04 29.95,77.67 30.08,77.8 34.25,77.8
GND on TOP (solid shape): 153.09,35.89 153.09,34.57 153.17,34.49 153.17,34.47 153.72,34.47 154.53,33.67 154.53,32.9 154.77,32.66 154.77,32.66 155.79,32.66 156.12,32.66 156.39,32.38 156.39,29.46 156.27,29.34 155.58,29.34 155.51,29.41 155.51,31.9 155.3,32.1 154.13,32.1 153.78,32.46 153.78,33.63 153.47,33.93 153.33,33.93 153.32,33.94 153.19,33.96 153.06,33.94 153.06,33.93 152.72,33.93 152.61,34.05 151.58,34.05 151.44,33.91 151.44,32.03 151.75,31.72 151.75,30.43 151.62,30.3 148.79,30.3 148.6,30.11 148.6,29.34 148.81,29.12 151.35,29.12 151.58,28.89 151.58,27.51 151.63,27.46 152.71,27.46 152.81,27.35 152.81,26.47 152.08,25.73 148.34,25.73 147.56,26.52 147.56,31.47 147.99,31.9 147.99,34.75 148.09,34.85 149,34.85 150.25,36.09 152.89,36.09
GND on TOP (solid shape): 76.18,79.4 76.18,78.28 75.95,78.05 75.86,78.05 75.83,78.07 75.81,78.1 75.82,78.12 75.5,78.66 75.1,78.18 75.08,78.09 75,78.05 74.84,78.05 74.74,78.15 73.79,78.15 73.69,78.05 73.39,78.05 73.3,77.96 73.28,77.96 72.78,77.81 72.3,77.6 72.29,77.6 71.94,77.6 70.24,75.89 68.61,75.89 68.49,76.02 68.49,79.4 68.61,79.53 76.05,79.53
GND on TOP (solid shape): 98.46,71.93 98.46,71.66 98.41,71.53 98.42,71.39 98.49,71.24 98.62,71.13 98.62,71.13 98.71,71.04 99.83,71.04 99.85,71.02 99.85,70.48 99.47,70.1 99.47,69.44 99.22,69.19 99.22,68.45 99.17,68.4 97.77,68.4 97.7,68.48 97.7,69.3 97.73,69.37 97.75,69.44 97.75,69.8 97.73,69.87 97.7,69.94 97.7,70.31 97.73,70.38 97.75,70.46 97.75,70.81 97.73,70.89 97.7,70.96 97.7,71.33 97.73,71.4 97.75,71.48 97.75,71.83 97.74,71.87 97.73,71.92 97.73,71.95 97.74,71.98 97.76,71.99 98.39,71.99
GND on TOP (solid shape): 100.21,62.1 100.21,61.34 100.35,61.2 100.41,61.17 100.47,61.16 100.61,61.16 100.75,61.16 100.81,61.17 100.86,61.2 100.88,61.21 100.9,61.21 101.05,61.36 101.05,62 101.1,62.05 102.06,62.05 102.22,61.9 102.22,61.74 102.02,61.54 101.89,61.54 101.66,61.31 101.66,61.27 101.65,61.26 101.62,61.12 101.65,60.97 101.66,60.96 101.66,60.56 101.65,60.55 101.62,60.45 101.62,60.36 101.59,60.28 101.51,60.25 101.07,60.25 101.05,60.27 101.05,60.7 100.88,60.87 98.7,60.87 98.63,60.93 98.63,61.14 98.95,61.45 99.08,61.45 99.22,61.59 99.22,62.03 99.35,62.15 100.16,62.15
GND on TOP (solid shape): 73.94,104.79 73.94,96.15 74.62,95.2 75.74,95.52 75.76,95.54 75.78,95.54 78.49,95.54 78.66,95.37 78.66,94.24 78.5,94.08 74.69,94.08 74.25,94.53 73.98,94.67 73.75,94.85 73.65,94.95 73.3,95.51 73.18,96.15 73.18,96.57 72.55,97.2 72.55,99.52 72.45,99.62 71.43,99.62 71.3,99.49 71.3,99.07 71.23,98.99 70.86,98.99 70.8,99.06 70.8,101.27 70.9,101.37 70.9,104.94 70.91,104.98 70.95,104.99 73.74,104.99
GND on TOP (solid shape): 71.56,85.9 76.23,85.9 77.02,85.11 77.04,85.08 77.03,85.05 77.02,84.76 77.22,84.54 77.24,84.52 77.25,84.49 77.25,84 77.15,83.89 67.32,83.89 66.71,84.51 66.7,84.51 66.45,84.76 65.95,84.76 65.69,85.01 65.69,86.28 65.82,86.41 69.37,86.41 69.63,86.16 69.63,85.39 69.66,85.36 69.67,85.35 69.73,85.26 69.81,85.19 70.12,85.01 70.45,85.17 70.51,85.47 70.31,85.76 70.28,85.79 70.27,85.81 70.26,85.83 70.26,86.69 70.39,86.82 70.64,86.82
GND on TOP (solid shape): 95.18,104.9 95.19,104.89 95.19,104.87 95.19,95.87 95.68,94.95 96.71,94.84 97.16,94.84 97.37,94.63 97.37,93.82 97.14,93.6 95,93.6 92.87,95.73 92.87,97.18 92.62,97.43 91.42,97.43 90.18,96.19 90.18,94 89.06,92.89 88.37,92.89 88.2,93.06 85.96,93.06 85.88,93.14 85.88,95.42 86.01,95.54 86.82,95.54 86.84,95.54 86.86,95.52 87.98,95.2 88.66,96.15 88.66,104.79 88.86,104.99 95.09,104.99
GND on TOP (solid shape): 150.06,67.21 150.06,65.9 150.31,65.65 151.35,65.65 151.56,65.43 151.56,63.03 151.54,62.91 151.56,62.79 151.56,62.4 151.55,62.33 151.54,62.26 151.54,60.5 151.42,60.37 144.27,60.37 144.15,60.5 144.15,60.93 144.63,61.42 144.63,62.2 144.43,62.41 141.76,62.41 141.64,62.53 141.64,62.79 141.38,63.04 140.11,63.04 139.86,62.79 139.86,62.41 139.78,62.33 135.46,62.33 135.43,62.34 135.41,62.38 135.41,62.42 134.66,62.42 134.66,62.38 134.64,62.34 134.6,62.33 133.71,62.33 133.51,62.53 133.51,63.27 133.76,63.52 135.11,63.52 135.14,63.51 135.16,63.47 135.16,63.17 135.54,62.79 135.92,63.17 135.92,63.52 135.93,63.52 138.97,63.52 143.09,67.65 149.63,67.65
GND on TOP (solid shape): outline of 82 points within 40.39,64.05 43.5,71.8
GND on TOP (solid shape): 89.03,83.12 89.03,81.97 88.64,81.58 87.54,81.58 87.15,81.2 87.15,80.06 87.14,80.04 87.05,80 86.98,79.95 86.96,79.94 86.95,79.93 85.97,79.93 85.76,80 85.54,79.93 84.45,79.93 84.23,80 84.02,79.93 82.92,79.93 82.71,80 82.49,79.93 81.4,79.93 81.19,80 80.97,79.93 79.38,79.93 79.35,79.95 79.33,79.98 79.33,79.99 77.82,79.99 77.82,80 77.82,81.52 79.03,82.73 80.04,82.73 80.05,82.72 80.12,82.61 80.23,82.54 80.23,82.53 80.55,82.22 80.62,82.22 80.65,82.19 86.83,82.19 86.85,82.22 87.03,82.22 87.66,82.85 87.66,83.11 87.79,83.23 88.92,83.23
GND on TOP (solid shape): 160.69,72.44 161.86,72.44 162.34,71.95 162.34,70.36 162.3,70.28 162.21,70.26 161.96,70.26 161.76,70.11 161.74,70.06 161.69,70.03 161.18,70.03 161.11,70.05 161.08,70.12 161.23,70.42 161.04,70.8 161.08,70.88 161.09,71.48 160.5,71.36 160.43,71.31 160.34,71.34 160.31,71.37 160.31,72.29 160.46,72.44 160.69,72.44
GND on TOP (solid shape): 115.09,107.39 115.09,100.1 115.1,100.01 115.11,99.92 115.11,98.28 114.81,97.99 113.19,97.99 112.94,97.74 112.94,96.09 112.71,95.86 111.25,95.86 110.51,95.12 109.34,94.08 107.78,94.3 107.58,94.3 107.52,94.35 107.52,95.01 107.58,95.06 108.04,95.06 109.24,94.85 109.91,95.87 109.91,104.89 110.01,104.99 111.8,104.99 112.51,105.29 112.81,106 112.81,107.29 113.01,107.49 114.99,107.49
GND on TOP (solid shape): 91.22,79.28 91.22,75.49 91.35,75.36 91.35,74.85 91.22,74.73 90.86,74.73 90.74,74.6 90.74,74.57 90.72,74.52 90.71,74.48 90.71,74.19 90.72,74.15 90.74,74.1 90.74,73.42 90.7,73.34 90.62,73.32 90.29,73.18 90.22,72.83 90.2,72.73 90.12,72.69 88.58,72.69 88.45,72.82 88.45,73.12 89.31,73.99 89.31,75.33 89.56,75.59 89.65,75.61 89.73,75.56 90.45,75.64 89.81,75.99 89.7,75.98 89.64,76.07 89.64,79.55 89.72,79.63 90.87,79.63
GND on TOP (solid shape): 101.85,85.24 101.94,85.19 101.94,85.09 101.88,84.86 101.97,84.64 101.98,84.6 101.97,84.57 101.91,84.49 101.89,84.4 101.89,84.12 101.91,84.02 101.97,83.95 102,83.87 101.97,83.79 101.91,83.71 101.89,83.62 101.89,83.34 101.96,83.18 102.15,83.1 102.17,83.06 102.17,81.94 102.14,81.91 99.12,81.91 98.94,82.09 98.94,84.4 99.09,84.55 99.98,84.55 100.24,84.46 100.49,84.55 100.74,84.55 101.26,84.56 101.29,85.08 101.28,85.1 101.28,85.14 101.38,85.24
GND on TOP (solid shape): outline of 106 points within 82.33,72.13 85.02,78.08
GND on TOP (solid shape): outline of 108 points within 167.04,51.91 184.85,60.25
GND on TOP (solid shape): outline of 133 points within 105.21,67.61 112.68,70.13
GND on TOP (solid shape): outline of 93 points within 96.07,60.83 102.93,66.57
GND on TOP (solid shape): outline of 196 points within 108.87,19.94 112.48,24.81
GND on TOP (solid shape): outline of 103 points within 88.68,66.51 94.52,70.1
GND on TOP (solid shape): outline of 382 points within 64.8,46 79.2,58.34
GND on TOP (solid shape): outline of 467 points within 124.24,62 186.49,107.49
GND on TOP (solid shape): outline of 637 points within 0.51,0.51 187.49,107.49
GND on TOP (solid shape): outline of 1721 points within 84.31,52.91 94.6,66.62
GND on BOTTOM (solid shape): 50.45,48.94 50.45,47.29 50.07,46.91 48.17,46.91 47.78,47.29 47.78,49.07 48.04,49.33 50.07,49.33
GND on BOTTOM (solid shape): 55.02,84.12 55.02,83.23 53.25,81.46 50.58,81.46 50.07,81.96 50.07,83.74 50.96,84.63 54.52,84.63
GND on BOTTOM (solid shape): 55.53,67.69 55.53,65.43 55.48,65.38 53.17,65.38 53.12,65.43 53.12,67.71 53.17,67.77 55.45,67.77
GND on BOTTOM (solid shape): 118.8,95.91 118.8,93.8 118.65,93.65 117.33,93.65 117.15,93.83 117.15,95.98 117.2,96.04 118.68,96.04
GND on BOTTOM (solid shape): 141.13,73.07 141.13,70.79 141,70.66 139.48,70.66 139.35,70.79 139.35,73.07 139.48,73.2 141,73.2
GND on BOTTOM (solid shape): 145.62,12.04 145.62,9.45 145.47,9.29 142.6,9.29 142.45,9.45 142.45,11.73 142.96,12.24 145.42,12.24
GND on BOTTOM (solid shape): 150.15,61.14 150.15,60.37 150.02,60.25 144.3,60.25 144.18,60.37 144.18,61.14 144.3,61.26 150.02,61.26
GND on BOTTOM (solid shape): 151.8,21.26 151.8,19.86 151.67,19.73 148.5,19.73 148.37,19.86 148.37,22.15 148.5,22.27 150.78,22.27
GND on BOTTOM (solid shape): 166.28,19.23 166.28,14.53 166.02,14.27 164.88,14.27 164.75,14.4 164.75,18.21 165.89,19.35 166.15,19.35
GND on BOTTOM (solid shape): 48.17,72.31 48.17,66.17 47.3,65.31 46.65,65.31 46.48,65.47 46.48,71.16 47.05,71.74 47.05,72.32 47.13,72.4 48.08,72.4
GND on BOTTOM (solid shape): 116.24,38.28 116.24,34.09 115.98,33.83 112.81,33.83 111.41,35.23 111.41,37.9 112.2,38.68 115.83,38.68
GND on BOTTOM (solid shape): 150.65,57.33 150.65,53.14 150.53,53.01 150.02,53.01 149.89,53.14 149.89,55.17 148.62,56.44 148.62,57.33 148.75,57.45 150.53,57.45
GND on BOTTOM (solid shape): 165.13,52.63 165.13,51.61 165.01,51.48 163.48,51.48 163.35,51.61 163.35,52.63 163.48,52.75 165.01,52.75
GND on BOTTOM (solid shape): 131.86,76.76 131.86,75.49 131.73,75.36 131.73,75.36 128.17,75.36 128.05,75.49 128.05,76.76 128.18,76.88 131.73,76.88
GND on BOTTOM (solid shape): 47.02,11.04 47.02,9.04 46.9,8.91 45.02,8.91 44.86,9.07 44.86,10.84 45.68,11.66 46.41,11.66
GND on BOTTOM (solid shape): 83.24,92 83.24,89.63 83.23,89.6 83.19,89.58 81.31,89.58 81.19,89.71 81.19,90.47 82.84,92.12 83.12,92.12
GND on BOTTOM (solid shape): 105.8,15.14 105.8,11.96 105.7,11.86 102.01,11.86 101.89,11.99 101.89,14.53 101.99,14.63 103.69,14.63 104.27,15.21 105.72,15.21
GND on BOTTOM (solid shape): 136.44,20.46 136.44,19.76 136.25,19.57 135.3,19.57 135.08,19.78 132.61,19.78 132.2,19.38 131.85,19.38 131.68,19.54 131.68,20.33 131.88,20.53 136.37,20.53
GND on BOTTOM (solid shape): 151.75,28.72 152.23,28.72 152.28,28.67 152.28,27.02 151.61,26.36 149.8,26.36 149.49,26.67 149.49,28.5 150.16,29.17 151.3,29.17
GND on BOTTOM (solid shape): 136.99,83.34 136.99,81.46 136.63,81.1 131.76,81.1 131.73,81.08 125.38,81.08 125.25,81.2 125.25,82.22 125.51,82.47 135.54,82.47 135.59,82.52 135.59,83.56 135.67,83.64 136.68,83.64
GND on BOTTOM (solid shape): 163.74,58.47 163.74,56.28 163.53,56.08 160.51,56.08 160.43,56.01 160.43,52.12 160.31,51.99 159.8,51.99 159.29,52.5 159.29,58.47 159.42,58.6 163.61,58.6
GND on BOTTOM (solid shape): 175.2,53.43 184.44,53.43 184.85,53.02 184.85,52.3 184.46,51.91 175.26,51.91 174.02,53.15 173.22,53.15 173.21,53.14 169.45,53.14 169.32,53.26 169.32,54.66 169.57,54.91 173.72,54.91
GND on BOTTOM (solid shape): 29.57,84.12 31.48,84.12 31.48,84.12 32.29,84.12 32.54,83.87 32.54,81.58 32.29,81.33 28.99,81.33 28.73,81.58 28.73,83.87 28.99,84.12 29.57,84.12
GND on BOTTOM (solid shape): 131.12,67.49 131.12,65.38 129.62,63.88 128.1,63.88 127.74,64.23 127.74,65.33 128.94,66.52 128.94,66.8 128.94,67.94 128.95,67.98 128.99,67.99 130.61,67.99
GND on BOTTOM (solid shape): 149.38,67.36 150.27,67.36 150.4,67.23 150.4,65.96 150.27,65.84 149.38,65.84 149,65.45 148.37,65.45 148.24,65.58 148.24,67.61 148.37,67.74 149,67.74
GND on BOTTOM (solid shape): 161.83,37.13 161.83,34.72 162.4,34.15 162.4,30.85 162.34,30.78 161.2,30.78 160.81,30.4 160.23,30.4 159.29,31.34 159.29,33.07 161.07,34.85 161.07,37.13 161.2,37.26 161.7,37.26
GND on BOTTOM (solid shape): 164.24,64.44 164.24,63.3 164.75,62.79 164.75,61.64 164.62,61.52 164.37,61.52 164.24,61.64 163.35,61.64 163.23,61.77 163.23,64.44 163.35,64.57 164.12,64.57
GND on BOTTOM (solid shape): 152.17,33.92 152.18,33.88 152.17,33.84 152.15,33.83 152.15,32.41 152.03,32.28 150.62,32.28 150.59,32.3 150.57,32.33 150.57,34 150.63,34.06 152.02,34.06
GND on BOTTOM (solid shape): 171.1,60.12 171.1,59.23 170.97,59.1 169.7,59.1 169.58,59.23 167.67,59.23 167.55,59.1 167.55,58.9 167.54,58.9 167.54,58.6 167.29,58.34 166.53,58.34 166.4,58.47 166.4,60.12 166.53,60.25 170.97,60.25
GND on BOTTOM (solid shape): 34.19,41.52 35.4,41.52 36.73,40.18 36.73,37.51 35.21,35.99 35.21,33.58 34.96,33.32 34.07,33.32 33.69,33.7 33.69,36.75 35.21,38.28 35.21,39.17 34.96,39.42 34.32,39.42 34.07,39.67 34.07,41.45 34.14,41.52 34.18,41.52
GND on BOTTOM (solid shape): 135.67,74.09 135.67,73.71 135.8,73.58 136.56,73.58 136.68,73.46 136.68,70.15 136.43,69.9 136.43,67.74 136.3,67.61 135.92,67.61 135.16,68.38 134.02,68.38 133.89,68.5 133.89,68.76 134.91,69.77 134.91,73.46 135.16,73.71 135.16,74.06 135.24,74.14 135.62,74.14
GND on BOTTOM (solid shape): 64.93,75.7 64.93,72.57 64.68,72.31 62.01,72.31 61.63,72.69 60.15,72.69 60.12,72.71 60.1,72.74 60.1,76.58 60.12,76.62 60.15,76.63 61.35,76.63 61.75,77.04 63.6,77.04
GND on BOTTOM (solid shape): 112.86,91.82 112.86,91.01 112.99,90.88 114.81,90.88 114.94,90.75 114.94,88.7 114.74,88.49 113.87,88.49 113.82,88.44 113.8,88.44 112.82,87.46 110.81,87.46 110.77,87.43 109.51,87.43 109.25,87.17 109.25,86.16 109.13,86.03 108.24,86.03 107.86,86.41 107.86,91.87 108.07,92.09 112.59,92.09
GND on BOTTOM (solid shape): 122.46,87.04 122.46,86.66 121.83,86.03 121.83,84.38 122.21,84 122.21,81.46 122.08,81.33 119.67,81.33 119.54,81.46 119.54,82.42 119.62,82.5 119.62,83.11 119.31,83.41 118.04,83.41 116.91,84.54 116.91,86.19 117,86.28 118.02,86.28 118.4,86.66 119.29,86.66 119.79,87.17 122.33,87.17
GND on BOTTOM (solid shape): 137.04,19.23 138.83,19.23 139.14,18.91 139.14,16.1 139.48,15.77 139.48,15.16 139.35,15.04 137.07,15.04 136.94,15.16 136.94,16.98 136.85,17.07 136.72,17.07 136.68,17.11 135.89,17.11 135.89,17.1 135.8,17.19 135.8,18.95 136.08,19.23 137.03,19.23
GND on BOTTOM (solid shape): 124.75,95.76 124.75,95.2 123.65,94.11 123.65,92.96 123.48,92.78 121.06,92.78 120.92,92.92 120.92,94.09 120.99,94.16 122.82,94.16 123.85,95.19 123.86,95.19 124,95.28 124.09,95.42 124.09,95.43 124.14,95.48 124.14,95.73 124.26,95.86 124.64,95.86
GND on BOTTOM (solid shape): 58.69,10.5 58.69,9.01 58.48,8.8 57.56,8.8 57.22,8.46 57.22,8.35 57.21,8.34 57.13,8 57.21,7.66 57.22,7.65 57.22,7.61 57.06,7.45 56.72,7.45 56.56,7.61 56.56,10.15 57.05,10.64 58.55,10.64
GND on BOTTOM (solid shape): 87.41,81.96 87.41,80.19 87.28,80.06 80.14,80.06 79.69,79.6 78.95,79.6 78.9,79.65 78.9,80.21 78.87,80.24 78.87,80.25 78.86,80.25 78.77,80.34 77.76,80.34 77.58,80.52 77.58,81.99 77.6,82.01 78.06,82.01 78.11,81.96 78.11,81.35 78.14,81.33 79.48,81.33 79.53,81.38 79.53,81.96 79.66,82.09 87.28,82.09
GND on BOTTOM (solid shape): 42.15,9.35 42.15,6.75 40.99,5.6 40.99,5.6 40.54,5.23 40.15,4.79 40.13,4.78 40.11,4.77 34.96,4.77 34.68,5.05 34.68,7.19 34.83,7.34 37.75,7.34 38.03,7.62 38.03,8.56 38.82,9.34 38.83,9.34 38.83,9.36 39.02,9.55 41.94,9.55
GND on BOTTOM (solid shape): 42.89,21.32 42.89,19.48 43.09,19.29 43.09,18.21 42.83,17.96 42.07,17.96 41.31,18.72 40.98,18.72 40.97,18.75 40.62,18.97 40.27,18.75 40.26,18.72 39.91,18.72 39.78,18.85 39.78,21.16 40.39,21.77 42.45,21.77
GND on BOTTOM (solid shape): 43.72,54.43 43.72,48.31 43.67,48.26 43.47,48.26 43.42,48.31 43.42,49.35 43.31,49.45 40.34,49.45 40.21,49.33 40.21,48.31 40.16,48.26 39.96,48.26 39.91,48.31 39.91,52.35 39.78,52.47 38.74,52.47 38.72,52.5 38.72,52.73 38.74,52.75 39.76,52.75 40.27,53.26 43.26,53.26 43.42,53.41 43.42,54.43 43.44,54.46 43.69,54.46
GND on BOTTOM (solid shape): 171.61,69.14 173.13,69.14 173.26,69.01 173.26,67.74 173.13,67.61 168.94,67.61 168.82,67.49 168.82,66.6 168.69,66.47 168.59,66.47 168.34,66.22 167.8,66.22 167.67,66.09 167.67,65.58 167.55,65.45 166.28,65.45 165.12,66.61 168.56,66.61 168.56,67.45 168.34,67.45 168.34,66.61 165.12,66.61 165.01,66.72 163.23,66.72 163.18,66.77 163.18,67.69 163.23,67.74 167.11,67.74 167.27,67.89 167.27,68.98 167.67,69.39 171.36,69.39
GND on BOTTOM (solid shape): 42.58,71.68 42.58,65.45 42.83,65.2 42.83,64.29 42.48,63.93 41.56,63.93 41.43,64.05 41.43,64.44 41.46,64.47 41.48,64.47 41.77,64.73 41.68,65.11 41.43,65.36 41.43,67.49 40.8,68.12 40.42,68.12 40.29,68.25 40.29,71.68 40.42,71.8 42.45,71.8
GND on BOTTOM (solid shape): 75.14,79.42 75.14,78.47 75.09,78.32 75.11,78.16 75.11,78.13 75.1,78.11 75.02,78.04 75,78.03 74.99,78.03 74.12,78.08 73.26,77.95 73.25,77.95 72.3,77.95 70.31,75.97 68.23,75.97 68.1,76.1 68.1,79.4 68.21,79.5 75.06,79.5
