# Allegro board Quanta ZHE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TPM_BADD: length 3.1
  TOP w0.127: R205.2 43.22,50.73 v1(43.21,50.72)
  TOP w0.254: v1(45.36,50.61) 45.24,50.73 R205.2
  BOTTOM w0.254: U28.6 v1(45.36,50.61)
TPM_SERIRQ: length 4.6
  BOTTOM w0.127: U23.4 41.56,57.69 41.71,57.54 41.71,57.09 R524.2 v1(41.06,55.42) U28.27
TPM_VDD: length 15.2
  TOP w0.254: v1(45.37,52.51) R195.2 R184.2
  BOTTOM w0.254: U28.22 38.69,52.11 38.19,52.61 38.19,53.33 37.88,53.64 37.72,53.64 C412.1 ; C417.1 44.74,49.29 U28.8 ; U28.14 41.06,47.77
  BOTTOM w0.508: v1(45.75,48.65) C418.1 C417.1 ; v1(38.13,54.88) R528.2 C412.1 ; v1(42.2,46.66) 41.78,47.07 C422.1 C421.1 40.55,47.25 41.06,47.77
TS_EN: length 228.3
  TOP w0.127: U14.32 23.75,25.98 25.25,27.48 v1(27.83,27.48)
  IN2 w0.127: v1(45.88,20.88) 45.87,20.86 39.29,20.86 38.01,22.15 32.29,22.15 31.66,21.51 30.59,21.51 29.93,22.17 29.12,22.17 28.14,23.15 28.14,27.17 v1(27.83,27.48)
  IN3 w0.127: v1(173.51,65.33) 172.05,63.87 172.05,62.34 173.06,61.34 173.06,56.32 162.91,46.17 162.91,37.42 161.89,36.4 161.89,35.04 162.77,34.17 162.77,31.13 161.46,29.83 160.1,29.83 159.87,30.06 157.74,30.06 156.95,30.85 149.86,30.85 149.37,30.36 148.07,30.36 147.41,29.7 144.33,29.7 141.13,26.49 141.13,25.7 140.88,25.45 139.1,25.45 137.76,26.78 128.88,26.78 128.25,26.15 128.25,23.11 125.72,20.58 122.03,20.58 116.42,14.97 105.13,14.97 104.37,14.21 93.57,14.21 92.68,15.1 87.53,15.1 85.32,12.89 74.88,12.89 72.99,11 59.49,11 59.14,11.35 57.03,11.35 54.94,13.45 49.67,13.45 46.5,16.62 46.5,20.26 v1(45.88,20.88)
  BOTTOM w0.127: R448.1 C375.2 170.97,77.14 172.63,77.14 175.42,74.34 177.45,74.34 177.95,73.85 177.95,69.56 177.78,69.39 174.66,69.39 173.51,68.25 v1(173.51,65.33)
TSEN_VCGI: length 3.8
  BOTTOM w0.127: PU10.16 56.93,67.36 57.31,67.74 v1(57.31,68.55) 57.31,69.13 PR160.1 PR157.1
TSEN_VNN: length 15.3
  TOP w0.178: PR28.1 30.54,67.11 v1(30.64,67.01)
  TOP w0.203: PU1.16 30.38,66.35 30.01,66.72 PR28.1
  IN2 w0.178: v1(30.64,67.01) 32.19,67.01 32.42,67.23 35.24,67.23 37.22,69.21 39.15,69.21 39.48,69.54 39.73,69.54 39.91,69.37 v1(39.91,68.38)
  BOTTOM w0.254: PR159.1 v1(39.91,68.38)
TX0_HDMI+: length 24.1
  TOP w0.102: CN1.7 122.65,98.25 127.77,98.25 127.92,98.09 127.92,97.02 127.89,96.99 127.66,96.99 127.65,96.97
  TOP w0.14: U6.17 120.27,87.88 120.54,88.16 120.54,88.78 121.3,89.54 121.3,90.9 v1(120.96,91.24) 121.3,91.57 121.3,92.26 R18.2 121.31,92.51 121.31,93.33 121.46,93.48 U2.6 U2.5 121.44,94.83 121.44,95.64 122.49,96.7 127.37,96.7 127.65,96.97
TX0_HDMI-: length 24.1
  TOP w0.102: 128.03,96.82 128.03,96.85 128.12,96.94 128.12,98.18 127.85,98.45 122.74,98.45 122.44,98.75 122.44,99.04 122.5,99.1 CN1.9
  TOP w0.14: 128.03,96.82 128.03,96.62 127.58,96.18 122.71,96.18 121.96,95.43 U2.4 U2.7 121.96,93.35 121.83,93.22 121.83,92.51 R18.1 121.82,92.23 121.82,91.65 v1(122.23,91.24) 121.82,90.82 121.82,89.32 121.06,88.57 121.06,87.94 120.67,87.54 U6.16
TX1_HDMI+: length 12.2
  TOP w0.14: U6.20 119.07,87.55 119.01,87.61 119.01,88.66 119.15,88.8 119.15,89.21 v1(118.78,89.58) 119.15,89.96 119.15,92.25 R17.2 119.15,92.51 119.15,92.85 119.02,92.98 U1.9 U1.2 119.02,95.35 119.01,95.36 119.01,96.13 119.7,96.82 120.4,96.82 120.54,96.96 120.54,97.36 CN1.4
TX1_HDMI-: length 12.2
  TOP w0.14: U6.19 119.47,87.77 119.53,87.83 119.53,88.44 119.67,88.59 119.67,89.21 v1(120.05,89.58) 119.67,89.96 119.67,92.25 R17.1 119.67,92.51 119.67,93.06 119.52,93.21 U1.10 U1.1 119.52,95.35 119.53,95.36 119.53,95.92 119.92,96.3 120.62,96.3 121.06,96.75 121.06,97.36 CN1.6
TX2_HDMI+: length 13.3
  TOP w0.14: U6.23 117.87,87.83 117.37,88.32 117.37,90.45 v1(116.97,90.85) 117.37,91.25 117.37,92.25 R16.2 117.37,92.51 117.37,93.24 117.52,93.39 U1.6 U1.5 117.52,95.35 117.51,95.36 117.51,97.49 118.92,98.9 118.92,98.98 CN1.1
TX2_HDMI-: length 13.3
  TOP w0.14: CN1.3 119.41,98.71 119.41,98.65 118.03,97.27 118.03,95.36 118.02,95.35 U1.4 U1.7 118.02,93.16 117.89,93.03 117.89,92.51 R16.1 117.89,92.25 117.89,91.2 v1(118.24,90.85) 117.89,90.5 117.89,88.28 118.27,87.91 U6.22
TXC_HDMI+: length 12.7
  TOP w0.14: U6.14 121.47,87.55 122.1,88.19 122.95,88.19 123.09,88.33 123.09,88.57 C17.2 123.09,88.82 123.09,89.59 v1(122.71,89.97) 123.09,90.34 123.09,92.25 R19.2 123.09,92.51 123.09,92.76 122.96,92.89 U2.9 U2.2 v1(122.96,95.55)
  BOTTOM w0.14: CN1.10 123.46,97.6 123.56,97.5 123.56,96.87 123.13,96.44 123.13,95.72 v1(122.96,95.55)
TXC_HDMI-: length 12.7
  TOP w0.14: U6.13 121.87,87.21 122.32,87.67 123.16,87.67 123.61,88.11 123.61,88.57 C17.1 123.61,88.82 123.61,89.59 v1(123.98,89.97) 123.61,90.34 123.61,92.25 R19.1 123.61,92.51 123.61,92.97 123.46,93.12 U2.10 U2.1 123.46,95.28 v1(123.73,95.55)
  BOTTOM w0.14: v1(123.73,95.55) 123.65,95.63 123.65,96.22 124.09,96.66 124.09,97.39 CN1.12
UGATE_VCGI: length 1.1
  BOTTOM w0.203: PU10.9 53.51,69.25 53.12,69.65
UGATE_VNN: length 5.2
  TOP w0.203: PU1.9 34.58,68.53 v2(34.93,68.88)
  IN1 w0.635: v2(38.64,68.63) 38.39,68.88 v2(34.93,68.88)
USB2.0_CONN3N: length 45.1
  IN1 w0.089: v1(103.97,68.82) 103.97,68.55 103.89,68.48 103.66,68.48 103.49,68.65 103.49,69.04 103.62,69.17 103.62,75.08 102.44,76.25 94.7,76.25 93.49,77.46 88.94,77.46 88.11,78.28 88.11,80 87.68,80.43 85.53,80.43 84.93,81.03 84.93,81.41 82.9,83.44 81.07,83.44 80.68,83.83 80.68,84.94 79.05,86.57 79.05,86.75 v1(79.37,87.07)
  BOTTOM w0.089: v1(103.97,68.82) 104.03,68.75 104.03,68.57 103.87,68.4 103.65,68.4 U22.R15
  BOTTOM w0.14: L11.1 76.38,87.56 76.11,87.3 76.11,87.03 76.22,86.93 76.68,86.93 77.82,88.07 78.63,88.07 79.03,87.68 79.03,87.41 v1(79.37,87.07)
USB2.0_CONN3P: length 45.2
  IN1 w0.089: v1(103.97,68) 103.97,68.2 103.88,68.29 103.59,68.29 103.3,68.57 103.3,69.12 103.43,69.25 103.43,75 102.37,76.06 94.62,76.06 93.41,77.27 88.86,77.27 87.92,78.2 87.92,79.92 87.6,80.24 85.45,80.24 84.74,80.95 84.74,81.33 82.82,83.25 80.99,83.25 80.49,83.75 80.49,84.86 78.85,86.49 78.85,86.75 v1(78.53,87.07)
  BOTTOM w0.089: U22.R13 104.32,68.36 v1(103.97,68)
  BOTTOM w0.14: v1(78.53,87.07) 78.76,87.3 78.76,87.57 78.52,87.81 77.93,87.81 76.79,86.66 76.11,86.66 75.84,86.92 75.84,87.3 75.58,87.56 L11.4
USB3_1_RXN: length 80.9
  TOP w0.14: R135.1 165.51,62.29 165.38,62.29 v1(165.13,62.53)
  IN1 w0.089: v1(105.86,71.47) 106.09,71.25 106.25,71.25 106.61,71.61 108.56,71.61 109.06,72.11 109.06,74.85 109.94,75.73 118.73,75.73 121.7,72.76 121.7,72.18 122.92,70.96 122.92,68.67 123.44,68.15 142.5,68.15 147.68,73.33 149.13,73.33 149.54,73.75 154.95,73.75 156.33,72.38 161.05,72.38 163.31,70.11 163.31,62.55 163.61,62.25 164.85,62.25 v1(165.13,62.53)
  BOTTOM w0.089: U22.H11 105.78,71.47 v1(105.86,71.47)
USB3_1_RXP: length 80.8
  TOP w0.14: R148.1 165.51,62.02 165.38,62.02 v1(165.13,61.77)
  IN1 w0.089: v1(105.86,70.84) 106.09,71.06 106.33,71.06 106.69,71.42 108.64,71.42 109.25,72.03 109.25,74.78 110.01,75.54 118.65,75.54 121.51,72.68 121.51,72.1 122.73,70.88 122.73,68.59 123.36,67.96 142.58,67.96 147.75,73.14 149.2,73.14 149.62,73.56 154.87,73.56 156.25,72.19 160.97,72.19 163.12,70.03 163.12,62.47 163.54,62.06 164.85,62.06 v1(165.13,61.77)
  BOTTOM w0.089: v1(105.86,70.84) 105.7,70.84 U22.J11
USB3_1_TXN: length 93.3
  TOP w0.14: C153.1 163.37,57.94 163.37,56.55 163.7,56.21 163.96,56.21 v1(164.12,56.06)
  IN1 w0.089: v1(105.57,76.76) 105.77,76.56 113.59,76.56 116.77,79.74 123.43,79.74 123.92,79.25 129.93,79.25 130.94,78.24 130.94,75.39 133.17,73.16 137.48,73.16 138.46,72.17 145.59,72.17 147.41,74 148.34,74 149.57,75.23 152.06,75.23 152.35,75.53 154.42,75.53 154.95,74.99 154.95,74.69 156.6,73.04 161.32,73.04 161.8,72.55 165.17,72.55 165.72,72 165.72,66.77 167.29,65.2 167.29,64.42 166.59,63.72 166.59,57.32 165.55,56.28 164.34,56.28 v1(164.12,56.06)
  BOTTOM w0.089: v1(105.57,76.76) 105.37,76.55 105.11,76.55 104.48,75.92 104.48,75.35 U22.A14
USB3_1_TXP: length 93.3
  TOP w0.14: C154.1 163.89,58.21 163.64,57.95 163.64,56.66 163.82,56.48 163.96,56.48 164.12,56.63 v1(164.12,56.69)
  IN1 w0.089: v1(105.57,76.12) 105.57,76.27 105.67,76.37 113.67,76.37 116.85,79.55 123.35,79.55 123.84,79.06 129.85,79.06 130.75,78.16 130.75,75.31 133.09,72.97 137.4,72.97 138.39,71.98 145.66,71.98 147.49,73.81 148.42,73.81 149.65,75.04 152.14,75.04 152.43,75.33 154.34,75.33 154.76,74.92 154.76,74.61 156.52,72.85 161.24,72.85 161.72,72.36 165.09,72.36 165.53,71.92 165.53,66.69 167.1,65.12 167.1,64.5 166.4,63.8 166.4,57.4 165.48,56.47 164.18,56.47 164.12,56.54 v1(164.12,56.69)
  BOTTOM w0.089: U22.C14 104.06,74.38 104.06,74.62 104.13,74.69 104.21,74.69 104.37,74.85 104.37,75.01 104.65,75.29 104.65,75.84 105.19,76.38 105.45,76.38 105.57,76.25 v1(105.57,76.12)
USB30_RX0+_R: length 10.5
  TOP w0.14: R31.2 100.76,86.79 100.76,86.93 100.98,87.16 101.21,87.16 101.5,87.45 101.5,88.82 101.37,88.95 101.37,89.59 U5.5 101.37,89.86 101.37,90.46 100.95,90.88 100.51,90.88 100.27,91.12 100.27,93.61 99.84,94.04 99.84,94.44 100.06,94.67 CN2.6
USB30_RX0-_R: length 10.5
  TOP w0.14: CN2.5 98.83,94.67 100.01,93.5 100.01,91.01 100.4,90.61 100.84,90.61 101.1,90.35 101.1,88.84 101.24,88.71 101.24,88.06 U5.6 101.24,87.79 101.24,87.56 101.1,87.43 100.87,87.43 100.49,87.04 100.49,86.8 R30.2
USB30_RX0N: length 39.8
  TOP w0.14: v1(100.24,84.84) 100.53,85.13 100.53,85.5 100.39,85.64 R30.1
  IN3 w0.089: v1(104.02,73.61) 104.02,73.86 103.79,74.09
  IN3 w0.127: 103.79,74.09 103.52,74.36 103.52,75.75 102.88,76.4 102.88,76.86 103.11,77.09 103.43,77.09 103.59,77.24 103.59,79.06 103.4,79.26 102.75,79.26 102.47,79.53 102.47,80 102.75,80.27 103.4,80.27 103.52,80.4 103.52,80.8 103.38,80.95 102.54,80.95 102.29,81.2 98.73,81.2 98.33,81.6 98.33,83.48 98.22,83.59 95.87,83.59 95.73,83.45 95.73,82.66 95.46,82.4 94.8,82.4 94.52,82.68 94.52,83.17 94.48,83.21 91.49,83.21 91.21,83.48 91.21,84.5 91.47,84.76 98.94,84.76 99.37,84.33 100.36,84.33 100.56,84.53 100.56,84.75 100.47,84.84 v1(100.24,84.84)
  BOTTOM w0.089: U22.D15 103.44,73.33 103.44,73.69 103.51,73.76 103.87,73.76 v1(104.02,73.61)
USB30_RX0P: length 39.8
  TOP w0.14: R31.1 100.8,85.31 100.8,85.04 v1(101,84.84)
  IN3 w0.089: 104.17,74.09 104.42,73.84 104.42,73.3 v1(104.02,72.9)
  IN3 w0.127: 104.17,74.09 103.78,74.48 103.78,75.86 103.13,76.5 103.13,76.75 103.21,76.83 103.54,76.83 103.84,77.14 103.84,79.17 103.5,79.51 102.85,79.51 102.72,79.64 102.72,79.89 102.85,80.02 103.5,80.02 103.78,80.29 103.78,80.91 103.49,81.2 102.65,81.2 102.39,81.46 98.84,81.46 98.58,81.71 98.58,83.59 98.33,83.84 95.76,83.84 95.47,83.55 95.47,82.77 95.35,82.65 94.9,82.65 94.77,82.78 94.77,83.28 94.59,83.46 91.6,83.46 91.47,83.59 91.47,84.4 91.58,84.51 98.83,84.51 99.27,84.08 100.47,84.08 100.82,84.42 100.82,84.66 v1(101,84.84)
  BOTTOM w0.089: v1(104.02,72.9) 103.66,72.54 U22.F15
USB30_TX0+_C: length 1.7
  TOP w0.14: R33.1 103.12,85.64 102.98,85.5 102.98,84.59 102.98,84.58 102.98,84.56 C26.2
USB30_TX0+_R: length 12.5
  TOP w0.14: v1(102.43,91.36) 102.18,91.11 102.18,89.85 U5.4 102.18,89.6 102.18,88.78 102.26,88.7 102.26,87.45 102.41,87.3 102.64,87.3 102.91,87.03 102.91,86.79 R33.2
  IN1 w0.089: CN2.9 105.73,94.67 105.65,94.58 105.65,94.22 104.53,93.11 104.53,92.74 103.98,92.19 102.27,92.19 102.14,92.06 102.14,91.64 v1(102.43,91.36)
USB30_TX0-_C: length 1.8
  TOP w0.14: R32.1 102.72,85.19 102.72,84.7 102.28,84.26 C25.2
USB30_TX0-_R: length 12.4
  TOP w0.14: R32.2 102.64,86.79 102.64,86.92 102.53,87.03 102.3,87.03 101.99,87.34 101.99,87.83 U5.7 101.99,88.01 101.99,88.58 101.91,88.67 101.91,91.11 v1(101.66,91.36)
  IN1 w0.089: CN2.8 105.37,94.67 105.45,94.58 105.45,94.3 104.34,93.18 104.34,92.82 103.9,92.38 102.19,92.38 101.95,92.14 101.95,91.64 v1(101.66,91.36)
USB30_TX0N: length 37.4
  TOP w0.14: v1(105.54,77.52) 105.37,77.7 105.14,77.7 104.8,78.03 104.8,79.39 105.09,79.68 105.55,79.68 v1(106.05,80.18) 106.55,79.68 107.47,79.68 107.91,79.24 107.91,76.54 108.05,76.4 108.41,76.4 108.55,76.54 108.55,78.11 108.87,78.43 109.39,78.43 109.73,78.09 109.73,76.64 109.87,76.5 110.29,76.5 110.43,76.64 110.43,79.08 110.29,79.23 109.05,79.23 108.71,79.58 108.71,80.06 109.05,80.41 110.58,80.41 110.77,80.6 110.77,80.87 110.58,81.06 105.53,81.06 105.23,81.36 105.23,81.95 104.87,82.31 102.97,82.31 102.55,82.72 102.55,83.19 C25.1
  BOTTOM w0.089: v1(105.54,77.52) 105.33,77.73 105.14,77.73 105.01,77.6 105.01,76.93 103.83,75.75 103.83,74.86 103.89,74.77 103.89,74.54 103.83,74.45 103.64,74.26 U22.C15
USB30_TX0P: length 37.3
  TOP w0.14: C26.1 102.95,83.48 102.82,83.35 102.82,82.83 103.08,82.57 104.98,82.57 105.5,82.06 105.5,81.47 105.64,81.33 110.69,81.33 111.04,80.98 111.04,80.49 110.69,80.14 109.16,80.14 108.97,79.95 108.97,79.69 109.16,79.5 110.4,79.5 110.7,79.2 110.7,76.53 110.4,76.24 109.76,76.24 109.47,76.53 109.47,77.98 109.28,78.17 108.99,78.17 108.82,78 108.82,76.43 108.52,76.13 107.94,76.13 107.64,76.43 107.64,79.13 107.36,79.41 106.55,79.41 v1(106.05,78.91) 105.55,79.41 105.2,79.41 105.07,79.28 105.07,78.14 105.25,77.96 105.46,77.96 105.54,78.04 v1(105.54,78.15)
  BOTTOM w0.089: U22.B15 103.57,74.59 103.48,74.59 103.41,74.65 103.41,74.8 103.65,75.05 103.65,75.83 104.83,77.01 104.83,77.67 105.07,77.91 105.45,77.91 105.54,78 v1(105.54,78.15)
USB31_RX1+_R: length 11.5
  TOP w0.14: CN6.6 175.54,62.85 175.29,63.1 174.82,63.1 174.38,62.66 173.97,62.66 173.17,61.86 172.44,61.86 v1(171.98,61.4) 171.48,61.9 171.2,61.9 170.66,61.36 170.06,61.36 U8.5 169.62,61.36 169.1,61.36 168.93,61.19 167.67,61.19 167.32,61.54 167.32,61.88 167.18,62.02 167.04,62.02 R148.2
USB31_RX1-_R: length 11.5
  TOP w0.14: CN6.5 175.54,64.19 174.27,62.93 173.86,62.93 173.06,62.13 172.52,62.13 v1(171.98,62.67) 171.48,62.17 171.09,62.17 170.53,61.6 169,61.6 168.83,61.43 168.15,61.43 U8.6 167.94,61.43 167.81,61.43 167.59,61.65 167.59,61.99 167.29,62.29 167.04,62.29 R135.2
USB31_TX1+_R: length 11.9
  TOP w0.14: R160.2 166.66,59.71 166.95,59.99 167.37,59.99 167.65,60.28 167.71,60.34 169.03,60.34 169.15,60.46 169.72,60.46 U8.4 169.97,60.46 172.59,60.46 172.97,60.09 172.97,59.48 arc(173.06,59.03) 173.32,58.65 174.01,57.95 174.43,57.95 175.54,56.84 CN6.9
USB31_TX1-_R: length 11.9
  TOP w0.14: R154.2 167.03,60.26 167.26,60.26 167.6,60.61 167.91,60.61 U8.7 168.18,60.61 168.92,60.61 169.04,60.73 172.7,60.73 173.23,60.2 173.23,59.48 arc(173.3,59.13) 173.5,58.83 174.12,58.22 174.54,58.22 175.08,57.67 175.4,57.67 175.54,57.81 CN6.8
USB31_TX1N_C: length 3.8
  TOP w0.14: R154.1 165.5,60.25 163.86,60.25 163.28,59.67 163.28,59.17 C153.2
USB31_TX1P_C: length 3.7
  TOP w0.14: C154.2 163.69,58.99 163.55,59.12 163.55,59.55 163.97,59.98 165.52,59.98 R160.1
USB_BT_N: length 4.7
  BOTTOM w0.14: CN10.5 22.4,18.65 22.28,18.53 22.28,17.83 v1(22.79,17.32) 22.28,16.81 22.28,15.91 R596.1
USB_BT_P: length 4.7
  BOTTOM w0.14: CN10.3 21.9,18.65 22.02,18.53 22.02,17.82 v1(21.52,17.32) 22.02,16.82 22.02,15.95 R595.1
USB_CAR7_N: length 98.9
  TOP w0.14: R245.1 160.04,44.12 v1(159.42,44.12)
  IN1 w0.089: v1(159.42,44.12) 159.13,43.83 158.96,43.83 158.6,43.47 158.6,42.16 158.91,41.86 159.85,41.86 161.51,43.51 161.51,45.51 161.51,45.51 161.99,45.99 161.99,48.86 161.99,49.53 163.3,50.85 163.3,58.7 162.32,59.69 161.99,60.02 161.99,65.12 159.01,68.1 157.41,68.1 154.44,71.06 154.44,71.89 153.91,72.43 150.31,72.43 149.81,71.92 149.81,70.06 146.58,66.83 122.89,66.83 121.6,68.13 121.6,70.41 119.99,72.01 111.49,72.01 109.38,69.9 109.38,69.27 108.66,68.55 106.41,68.55 106.24,68.38 106.24,68.08 v1(106.1,67.95)
  BOTTOM w0.089: U22.U10 105.75,67.6 v1(106.1,67.95)
USB_CAR7_P: length 98.8
  TOP w0.14: R255.1 160.36,43.42 160.36,43.69 160.24,43.8 159.75,43.8 159.42,43.47 v1(159.42,43.36)
  IN1 w0.089: v1(106.81,67.95) 106.69,67.95 106.43,68.21 106.43,68.3 106.49,68.36 108.74,68.36 109.57,69.19 109.57,69.82 111.57,71.82 119.92,71.82 121.41,70.33 121.41,68.05 122.81,66.64 146.66,66.64 150,69.98 150,71.84 150.39,72.24 153.83,72.24 154.25,71.81 154.25,70.98 157.33,67.91 158.93,67.91 161.8,65.04 161.8,59.94 162.13,59.61 162.18,59.55 163.11,58.62 163.11,50.93 161.8,49.61 161.8,48.79 161.8,46.07 161.32,45.59 161.32,43.59 159.77,42.05 158.99,42.05 158.79,42.24 158.79,43.39 159.04,43.64 159.26,43.64 159.42,43.48 v1(159.42,43.36)
  BOTTOM w0.089: v1(106.81,67.95) 106.81,67.54 106.74,67.46 106.56,67.46 U22.U8
USB_CAR_N_R: length 2
  TOP w0.14: U11.2 162.3,43.98 162.19,43.86 161.33,43.86 R245.2
USB_CAR_P_R: length 2
  TOP w0.14: R255.2 161.32,43.6 162.17,43.6 162.29,43.48 U11.3
USB_CCD6_N_R: length 6.5
  BOTTOM w0.14: CN5.34 154.98,79.26 155.1,79.14 155.1,78.53 154.58,78.02 154.58,76.92 D37.2 154.38,76.12 154.46,76.12 154.58,76 154.58,74.6 R466.2
USB_CCD6_P_R: length 6.5
  BOTTOM w0.14: CN5.33 155.48,79.22 155.37,79.1 155.37,78.42 154.85,77.91 154.85,76.92 D38.2 155.06,76.12 154.97,76.12 154.85,76 154.85,74.6 R467.2
USB_OC0#: length 13.2
  TOP w0.14: v1(84.23,67.87) 79.41,67.87 79.03,68.25 77.27,68.25 76.49,67.48 R110.1 75.99,67.74 74.59,67.74 R109.2
  BOTTOM w0.079: 85.86,67.91 86.06,67.71 U22.U54
  BOTTOM w0.089: 85.86,67.91 85.76,68.02 84.37,68.02 v1(84.23,67.87)
USB_OC1#: length 176.5
  TOP w0.127: v1(92.31,96.8) 91.96,96.8 v1(91.67,96.5) 90.71,95.55 90.71,93.27 89.88,92.44 89.88,88.5 89.63,88.25 U4.3 86.08,88.25 84.36,86.54 82.02,86.54 76.89,81.41 76.89,79.31 79,77.2 79,76.22 80.72,74.51 80.72,73.29 v1(81.19,72.82)
  TOP w0.14: v1(83.72,67.34) 81.56,67.34 81.46,67.23 R112.2
  IN1 w0.089: v1(113.77,97.08) 113.19,96.5 113.19,93.25 111.57,91.63 108.89,91.63 107.9,90.63 100.02,90.63 97.51,93.14 93.88,93.14 92.67,94.34 92.67,96.43 v1(92.31,96.8)
  IN3 w0.127: v1(81.19,72.82) 81.69,72.82 83.09,71.42 83.09,70.65 83.61,70.13 83.61,67.45 v1(83.72,67.34) ; v1(164.75,53.14) 164.75,53.14 163.04,54.86 163.04,58.93 162.1,59.87 162.1,67.15 163.66,68.72 164.48,68.72 165.86,70.09 165.86,72.06 164.3,73.61 154.16,73.61 153.52,72.96 142.8,72.96 141.59,74.16 139.61,74.16 139.09,73.63 137.95,73.63 137.18,74.41 134.2,74.41 132.05,76.56 132.05,79.03 130.18,80.89 126.23,80.89 124.77,82.35 122.36,82.35 120.87,83.83 120.87,91.75 120.17,92.45 120.17,93.46 119.03,94.6 118.13,94.6 117.43,95.3 115.6,95.3 113.82,97.08 v1(113.77,97.08)
  BOTTOM w0.079: U22.U53 86.62,67.71 86.38,67.46 86.18,67.46 86.09,67.55 85.99,67.55 85.7,67.84
  BOTTOM w0.089: 85.7,67.84 84.86,67.84 84.36,67.34 v1(83.72,67.34)
  BOTTOM w0.127: U24.3 167.36,54.22 166.28,53.14 v1(164.75,53.14) ; U18.3 v1(113.77,97.08)
USB_OTG_ID: length 3.7
  BOTTOM w0.089: U22.V1 110,66.85 111.54,66.85 112.05,67.36 R481.2
USB_TS5_N_R: length 7
  BOTTOM w0.14: R464.2 151.66,74.6 151.66,75.24 152.03,75.6 v1(152.03,76.4) 152.65,76.4 153.6,77.35 153.6,79.03 153.48,79.15 CN5.37
USB_TS5_P_R: length 7
  BOTTOM w0.14: R465.2 151.93,74.6 151.93,75.13 152.16,75.36 v1(152.81,75.36) 152.81,76.19 153.87,77.24 153.87,79.03 153.98,79.15 CN5.36
USB_VBUS_SNS: length 6.1
  BOTTOM w0.089: U22.V3 109.21,67.26 109.48,66.99 109.5,66.99 109.89,66.6 112.67,66.6 R484.2
  BOTTOM w0.127: R492.1 113.41,65.53 v1(112.78,65.53) 112.78,66.2 R484.2
USBCOMP: length 1.6
  TOP w0.152: v1(104.69,68) 105.05,67.63 R113.1
  BOTTOM w0.305: v1(104.69,68) 105.04,67.65 U22.U12
USBON#: length 260.1
  TOP w0.127: v1(38.17,41.8) 38.17,41.99 38.78,42.6 R260.1 ; U4.4 90.71,88.25 90.39,88.57 90.39,91.69 90.96,92.27 v1(90.96,92.76) 90.96,95.17 91.26,95.46 v1(91.28,95.46)
  IN1 w0.089: v1(20.43,54.41) 21.62,55.59 21.62,70.41 21.24,70.78 21.24,76.88 23.15,78.8 48.03,78.8 54.18,84.95 57.26,84.95 57.66,85.35 57.66,87 58.22,87.56 63.19,87.56 68.53,92.91 88.7,92.91 91.26,95.46 v1(91.28,95.46) 93.8,92.95 97.43,92.95 99.94,90.44 107.98,90.44 108.97,91.44 111.65,91.44 113.38,93.17 113.38,96 v1(114.46,97.08)
  IN3 w0.127: v1(114.46,97.08) 115.98,95.55 117.53,95.55 118.23,94.85 119.13,94.85 120.42,93.57 120.42,92.56 121.13,91.85 121.13,83.94 122.47,82.6 124.88,82.6 126.33,81.14 130.29,81.14 132.3,79.13 132.3,76.67 134.31,74.66 137.28,74.66 138.06,73.89 138.98,73.89 139.51,74.41 141.7,74.41 142.9,73.21 153.41,73.21 154.06,73.86 164.41,73.86 166.11,72.16 166.11,69.99 164.58,68.46 163.77,68.46 162.35,67.04 162.35,59.97 163.29,59.03 163.29,55.23 v1(164.75,53.77)
  BOTTOM w0.127: v1(20.43,54.41) 21.32,53.52 v1(22.26,53.52) 24.09,53.52 25.06,52.55 25.81,51.8 25.81,51.28 26.91,50.18 27.55,49.54 28.65,48.44 29.24,48.44 32.54,45.13 35.21,45.13 37.34,43 37.9,43 38.17,42.74 v1(38.17,41.8) ; U24.4 165.52,53.77 v1(164.75,53.77) ; v1(114.46,97.08) 114.46,96.44 115.29,95.61 U18.4
USBP0+_R: length 15.3
  TOP w0.14: R34.2 104.68,86.67 104.85,86.84 104.85,87.06 104.4,87.5 104.4,87.82 U5.10 104.44,88.06 104.44,88.77 104.35,88.86 104.35,90.33 104.63,90.61 105.24,90.61 105.48,90.37 105.7,90.37 v1(106.2,90.87) 106.71,90.36 106.91,90.36 107.08,90.53 107.08,91.37 106.72,91.73 104.59,91.73 104.37,91.96 102.89,91.96 102.39,92.46 102.39,93.01 102.23,93.17 CN2.3
USBP0-_R: length 15.3
  TOP w0.14: R35.2 105.11,86.75 105.11,87.17 104.7,87.58 104.7,88.88 104.62,88.97 104.62,89.64 U5.1 104.62,89.81 104.62,90.22 104.74,90.35 105.13,90.35 105.37,90.1 105.7,90.1 v1(106.2,89.6) 106.7,90.09 107.02,90.09 107.35,90.42 107.35,91.49 106.84,92 104.71,92 104.48,92.23 103,92.23 102.66,92.57 102.66,93.05 102.78,93.17 CN2.2
USBP0N: length 34.1
  TOP w0.14: R35.1 105.07,85.26 105.07,85.03 v1(105.32,84.79)
  IN3 w0.089: v1(108.24,67.95) 108.19,67.99 108.05,67.99 107.49,68.55 105.77,68.55 105.44,68.88 105.44,69.77 104.93,70.28 104.93,74.58 104.97,74.61 104.97,74.64
  IN3 w0.127: 104.97,74.64 104.97,75.28 104.81,75.45 104.81,78.72 104.93,78.84 107.06,78.84 107.25,78.66 107.25,77.36 107.57,77.04 108.15,77.04 108.45,77.33 108.45,79.24 107.63,80.06 104.73,80.06 104.58,80.21 104.58,80.42 104.73,80.57 105.21,80.57 105.49,80.85 105.49,82.11 105.7,82.32 106.48,82.32 106.74,82.57 106.74,83.14 106.46,83.41 105.34,83.41 105.06,83.69 105.06,84.53 v1(105.32,84.79)
  BOTTOM w0.089: U22.U5 107.88,67.6 v1(108.24,67.95)
USBP0P: length 34.1
  TOP w0.14: v1(104.55,84.79) 104.8,85.03 104.8,85.26 R34.1
  IN3 w0.089: v1(107.53,67.95) 107.53,68.27 107.41,68.38 105.69,68.38 105.26,68.81 105.26,69.7 104.76,70.2 104.76,74.58 104.72,74.61 104.72,74.64
  IN3 w0.127: 104.72,74.64 104.72,75.18 104.55,75.34 104.55,78.82 104.82,79.09 107.17,79.09 107.5,78.76 107.5,77.47 107.68,77.29 108.05,77.29 108.2,77.44 108.2,79.13 107.52,79.81 104.62,79.81 104.32,80.1 104.32,80.52 104.62,80.82 105.11,80.82 105.24,80.95 105.24,82.22 105.59,82.57 106.38,82.57 106.48,82.68 106.48,83.03 106.36,83.16 105.23,83.16 104.81,83.59 104.81,84.53 v1(104.55,84.79)
  BOTTOM w0.089: v1(107.53,67.95) 107.53,67.59 107.42,67.49 107.25,67.49 U22.U7
USBP1+_R: length 10.4
  TOP w0.14: R168.2 167.07,58.19 167.49,58.19 167.5,58.2 167.91,58.2 U8.10 168.18,58.2 169.31,58.2 169.4,58.29 170.51,58.29 170.63,58.16 171.22,58.16 v1(171.49,58.44)
  BOTTOM w0.14: v1(171.49,58.44) 171.74,58.19 172.32,58.19 172.56,58.43 172.56,60.23 172.92,60.58 173.17,60.58 CN6.3
USBP1-_R: length 10.3
  TOP w0.14: v1(171.49,57.68) 171.27,57.9 170.56,57.9 170.41,58.05 169.95,58.05 U8.1 169.73,58.05 169.5,58.05 169.41,57.96 167.6,57.96 167.56,57.92 167.01,57.92 R172.2
  BOTTOM w0.14: v1(171.49,57.68) 171.74,57.92 172.43,57.92 172.83,58.32 172.83,60.12 173.03,60.32 173.17,60.32 CN6.2
USBP1N: length 80.2
  TOP w0.14: v1(164.75,57.7) 164.82,57.78 165.69,57.78 R172.1
  IN1 w0.089: v1(115.07,72.82) 115.34,73.09 115.34,73.78 115.66,74.1 119.43,74.1 121.04,72.49 121.04,71.9 122.26,70.69 122.26,68.4 123.16,67.49 146.31,67.49 149.15,70.33 149.15,72.2 150.04,73.09 154.68,73.09 156.32,71.45 156.32,70.69 158.25,68.76 159.28,68.76 162.65,65.39 162.65,60.29 163.25,59.69 165.1,59.69 165.53,59.27 165.53,58.26 165.17,57.9 164.95,57.9 v1(164.75,57.7)
  BOTTOM w0.089: 112.02,71.42 111.96,71.42 111.92,71.37 111.64,71.37 110.13,69.86 109.88,69.86 109.7,69.69 109.5,69.69 109.49,69.7 109.35,69.8 109.22,69.8 109.07,69.7 U22.N3
  BOTTOM w0.14: 112.02,71.42 113.11,71.42 113.54,71.85 115.1,71.85 115.24,72 115.24,72.64 v1(115.07,72.82)
USBP1P: length 80.1
  TOP w0.14: v1(164.75,58.46) 164.75,58.36 165.06,58.04 165.79,58.04 165.89,58.14 R168.1
  IN1 w0.089: v1(164.75,58.46) 164.75,58.15 164.81,58.09 165.09,58.09 165.34,58.34 165.34,59.19 165.02,59.5 163.17,59.5 162.46,60.21 162.46,65.31 159.21,68.57 158.17,68.57 156.13,70.61 156.13,71.37 154.6,72.9 150.12,72.9 149.34,72.12 149.34,70.26 146.39,67.3 123.08,67.3 122.07,68.32 122.07,70.61 120.85,71.83 120.85,72.41 119.35,73.91 115.74,73.91 115.53,73.7 115.53,72.9 115.61,72.82 v1(115.83,72.82)
  BOTTOM w0.089: U22.N2 109.52,69.51 109.52,69.51 109.59,69.51 109.59,69.51 109.76,69.51 109.94,69.69 110.2,69.69 111.71,71.19 111.93,71.19 111.97,71.15 112.02,71.15
  BOTTOM w0.14: 112.02,71.15 113.22,71.15 113.66,71.59 115.21,71.59 115.51,71.89 115.51,72.73 115.6,72.82 v1(115.83,72.82)
USBP3_C+: length 11.8
  BOTTOM w0.14: L11.3 75.58,90.21 75.71,90.35 75.71,92.62 76.12,93.03 78.6,93.03 79.28,92.35 79.8,92.35 ESD2.1 80.23,92.35 80.83,92.35 81.29,92.81 81.29,93.76 CN3.3
USBP3_C-: length 11.8
  BOTTOM w0.14: L11.2 76.38,89.84 75.98,90.24 75.98,92.51 76.23,92.76 76.61,92.76 76.62,92.75 76.84,92.75 ESD2.6 77.21,92.76 78.49,92.76 79.17,92.09 80.94,92.09 81.55,92.7 81.55,94 CN3.2
USBP4N: length 191.6
  IN3 w0.127: v1(112.34,72.99) 112.51,72.99 112.62,73.1 112.62,76.38 111.73,77.27 111.73,84.65 107.3,89.08 99.96,89.08 99.79,89.25 98.78,89.25 98.15,88.62 96.87,88.62 95.91,89.58 95.35,89.58 95.23,89.46 88.02,89.46 87.61,89.86 78.64,89.86 77.7,90.8 72.7,90.8 70.32,88.43 65.01,88.43 63.67,87.08 54.34,87.08 54.34,87.08 48.54,81.28 36.05,81.28 35.09,80.31 29.34,80.31 26.78,77.75 26.78,75.25 25.97,74.44 25.97,70.87 26.32,70.51 26.32,67.07 24.9,65.64 24.9,62.03 23.3,60.43 23.3,57.5 21.16,55.37 21.16,49.63 17.81,46.28 17.81,36.32 18.66,35.47 18.66,28.77 18.93,28.5 19.31,28.5 22.26,25.55 22.26,22.38 26.48,18.15 26.48,16.74 23.47,13.73 23.47,11.53 v1(23.72,11.28)
  BOTTOM w0.089: U22.M3 109.22,70.13 109.35,70.13 109.51,70.24 109.92,70.24 110.93,71.24 110.93,71.55 111.67,72.29 111.95,72.29 112,72.33 112.02,72.33
  BOTTOM w0.14: 112.02,72.33 112.37,72.33 112.66,72.62 112.66,72.92 112.58,72.99 v1(112.34,72.99) ; v1(23.72,11.28) 23.49,11.51 23.49,12.28 22.13,13.63 22.13,14.6 22.3,14.77 R596.2
USBP4P: length 191.6
  IN3 w0.127: v1(113.1,72.99) 112.87,73.22 112.87,76.49 111.98,77.38 111.98,84.75 107.41,89.33 100.07,89.33 99.89,89.51 98.67,89.51 98.04,88.87 96.97,88.87 96.01,89.83 95.25,89.83 95.12,89.71 88.12,89.71 87.72,90.12 78.75,90.12 77.81,91.06 72.59,91.06 70.22,88.68 64.91,88.68 63.56,87.34 54.24,87.34 54.23,87.32 48.43,81.53 35.95,81.53 34.98,80.57 29.23,80.57 26.52,77.86 26.52,75.36 25.71,74.55 25.71,70.77 26.07,70.41 26.07,67.17 24.64,65.75 24.64,62.14 23.04,60.54 23.04,57.61 20.91,55.48 20.91,49.74 17.56,46.38 17.56,36.22 18.41,35.37 18.41,28.66 18.83,28.24 19.21,28.24 22,25.45 22,22.27 26.23,18.05 26.23,16.85 23.22,13.83 23.22,11.53 v1(22.96,11.28)
  BOTTOM w0.089: U22.M1 109.69,70.06 110,70.06 111.11,71.17 111.11,71.47 111.74,72.11 111.95,72.11 112,72.06 112.02,72.06
  BOTTOM w0.14: 112.02,72.06 112.48,72.06 112.92,72.51 112.92,72.81 v1(113.1,72.99) ; v1(22.96,11.28) 23.22,11.54 23.22,12.16 21.86,13.52 21.86,14.53 R595.2
USBP6_CCDN: length 57.2
  IN1 w0.089: v1(152.05,71.04) 152.31,70.79 152.31,70.61 146.2,64.5 132.06,64.5 131.05,65.51 122.34,65.51 120.28,67.58 120.28,69.86 119.45,70.69 116,70.69 114.93,69.62 112.67,69.62 112.53,69.76 112.53,69.85 v1(112.82,70.13)
  BOTTOM w0.089: U22.P3 109.22,69.22 109.35,69.22 109.51,69.33 109.87,69.33 110.03,69.49 110.37,69.49 111.67,70.79 112.33,70.79 112.53,70.58 112.53,70.42 v1(112.82,70.13)
  BOTTOM w0.14: v1(152.05,71.04) 152.25,71.25 152.25,72.13 152.8,72.68 154.44,72.68 154.58,72.82 154.58,73.07 R466.1
USBP6_CCDP: length 57.2
  IN1 w0.089: v1(152.75,71.05) 152.5,70.79 152.5,70.53 146.28,64.31 131.99,64.31 130.98,65.32 122.26,65.32 120.09,67.5 120.09,69.78 119.37,70.5 116.08,70.5 115.01,69.43 112.59,69.43 112.34,69.68 112.34,69.85 v1(112.06,70.13)
  BOTTOM w0.089: U22.P1 109.59,68.93 109.65,68.88 109.81,68.88 109.87,68.94 109.87,69.09 110.1,69.31 110.44,69.31 111.74,70.61 112.25,70.61 112.35,70.51 112.35,70.43 v1(112.06,70.13)
  BOTTOM w0.14: R467.1 154.85,73.07 154.85,72.71 154.56,72.41 152.91,72.41 152.52,72.02 152.52,71.28 v1(152.75,71.05)
USBP_TOUCHN: length 54.1
  IN1 w0.089: v1(150.65,71.04) 150.9,70.8 150.9,70.13 146.93,66.17 122.62,66.17 120.94,67.85 120.94,70.14 119.72,71.35 114.24,71.35 113.99,71.11 113.99,70.41 v1(113.68,70.1)
  BOTTOM w0.089: U22.R3 108.83,68.78 109.04,68.78 109.2,68.89 109.37,68.89 109.49,68.8 109.62,68.67 109.8,68.67 110.07,68.4 110.88,68.4 112.02,69.54 113.83,69.54 113.98,69.69 113.98,69.81 v1(113.68,70.1)
  BOTTOM w0.14: R464.1 151.52,73.45 151.66,73.31 151.66,72.98 150.85,72.17 150.85,71.24 v1(150.65,71.04)
USBP_TOUCHP: length 54.1
  IN1 w0.089: v1(114.45,70.1) 114.18,70.37 114.18,71.03 114.32,71.16 119.64,71.16 120.75,70.06 120.75,67.77 122.54,65.98 147.01,65.98 151.09,70.05 151.09,70.84 v1(151.29,71.04)
  BOTTOM w0.089: v1(114.45,70.1) 114.15,69.81 114.15,69.62 113.9,69.37 112.09,69.37 110.95,68.22 110,68.22 109.95,68.27 109.95,68.28 109.73,68.5 109.56,68.5 109.35,68.3 109.23,68.3 109.15,68.38 109.15,68.48 U22.R2
  BOTTOM w0.14: v1(151.29,71.04) 151.12,71.21 151.12,72.06 151.93,72.87 151.93,73.31 152.07,73.45 R465.1
USBPWR1: length 11.2
  BOTTOM w0.305: ESD2.5 77.88,91.62 78.14,91.36 78.14,90.47 78.77,89.84 80.7,89.84 80.9,90.04 80.9,90.65 82.76,92.51 v1(85.48,92.51)
  vias: v1(86.16,92.51) v1(86.65,90.22) v1(86.87,92.51) v1(87.54,92.48) v1(88.17,92.48)
USBPWR2: length 1
  TOP w0.254: v1(170.85,58.72) 170.83,58.74 U8.2
  vias: v1(168.31,57.71)
USBPWR3: length 1.7
  TOP w0.203: U5.2 C15.2
  TOP w0.508: v1(103.79,91.36) 103.9,91.25 C15.2
  vias: v1(111.06,93.87) v1(111.44,94.38) v1(111.69,93.8)
VA: length 212.6
  TOP w0.508: PR128.1 145.7,4.47 v1(146.21,3.96)
  IN2 w0.508: v1(146.21,3.96) 145.55,4.62 138.03,4.62 132.39,10.27 126.83,10.27 124.37,7.8 113.44,7.8 112.55,6.91 64.73,6.91 64.27,7.37 61.04,7.37 60.58,6.91 40.09,6.91 39.05,5.87 18.37,5.87 15.6,8.63 15.6,16.46 16.58,17.43 16.58,26.12 15.79,26.92 15.79,82.1 v2(16.54,82.85)
  vias: v1(25.43,103.81) v2(17.3,82.85) v2(18.07,82.85) v2(18.83,82.85) v2(19.59,82.85) v2(20.35,82.85) v2(23.53,102.54) v2(23.53,101.65) v2(23.53,100.76) v2(24.42,102.54) v2(24.42,101.65) v2(24.42,100.76) v2(25.31,102.54) v2(25.31,101.65) v2(25.31,100.76) v2(26.19,102.54) v2(26.19,101.65) v2(27.08,102.54) v2(27.08,101.65) v2(27.97,102.54) v2(27.97,101.65)
VA1: length 151.2
  TOP w0.508: PC22.1 v1(18.96,72.31) 18.96,73.57 v1(18.19,74.34) ; v1(139.48,5.26) 139.48,4.74 PR125.2 138.46,4.74 v1(138.46,5.26)
  IN2 w1.016: 62.79,10.17 69.68,10.17 70.78,9.07 109.63,9.07 110.01,9.45 124.76,9.45 126.47,11.15 132.76,11.15 137.64,6.27 138.97,6.27 ; 50.65,11.76 49.35,11.76 46.71,14.4 42.76,14.4 38.06,9.7 22.38,9.7 21.29,10.79 21.29,12.62 19.34,14.58 19.34,16.66 20.51,17.84 20.51,20.6 21.6,21.69 21.6,23.73 22.13,24.27 22.13,29.61 19.69,32.05 19.69,34.59 18.22,36.07 18.22,38.28 19.69,39.75
VA2: length 208.5
  TOP w0.254: PR121.1 143.67,5.96 v1(143.74,5.89) ; v1(17.06,68.55) 17.16,68.55 18.13,69.52 PC27.1
  TOP w0.508: v1(22.56,71.5) 22.13,71.07 v1(22.13,70.41) 22.13,68.63 21.88,68.38 21.05,68.38 19.91,69.52 PC27.1
  IN3 w0.254: v1(143.74,5.89) 143.69,5.85 143.69,5.19 143.06,4.57 142.73,4.57 142.65,4.49 140.77,4.49 140.27,3.99 138.56,3.99 137.86,4.69 137.86,5.16 132.17,10.84 127,10.84 124.33,8.18 121.41,8.18 120.27,7.03 66.26,7.03 65.12,8.18 59.48,8.18 58.34,7.04 19.18,7.04 17.29,8.93 17.29,10.57 17.1,10.76 17.1,12.57 17.66,13.14 17.66,13.18 17.99,13.51 17.99,15.97 17.2,16.75 17.2,22.3 16.62,22.88 16.62,26.36 15.88,27.1 15.88,67.3 17.06,68.47 v1(17.06,68.55)
  BOTTOM w0.14: PR163.2 24.43,70.28 24.43,71.98 24.2,72.21 PR150.1
VCLK_VCGI: length 3.1
  BOTTOM w0.127: PU10.6 51.73,67.36 51.53,67.57 51.53,67.69 51.09,68.13 51.09,68.74 v1(51.01,68.83) 50.83,69.01 PR166.1
VCLK_VNN: length 2
  TOP w0.203: PR29.1 37.55,66.53 36.67,66.53 36.48,66.35 PU1.6
VDIO_VCGI: length 2.1
  BOTTOM w0.127: PU10.4 51.32,66.56 51.26,66.51 50.42,66.51 PR179.1
VDIO_VNN: length 2
  TOP w0.203: PR33.1 37.4,65.55 PU1.4
VL: length 114.5
  TOP w0.127: v1(159.42,40.18) 159.42,38.89 161.21,37.09 162.64,37.09 164,35.74 166.07,35.74 166.34,35.47 166.34,34.37 PR80.1
  IN3 w0.127: v1(159.42,40.18) 159.99,40.75 159.99,48.73 161.45,50.19 161.45,51.09 160.01,52.52 160.01,62.68 160.47,63.14 160.47,65.17 160.24,65.4 160.24,66.91 162.78,69.45 162.78,71.31 161.63,72.46 154.8,72.46 153.78,71.45 153.78,71.44 152.93,70.6 150.47,70.6 149.25,71.82 142.32,71.82 141.65,72.49 137.48,72.49 136.7,73.26 132.74,73.26 130.91,75.1 130.91,78.55 129.71,79.75 125.75,79.75 125.06,80.44 124.12,80.44 123.48,79.81 122.71,79.81 121.57,80.95 121,80.95 120.18,81.77 119.48,81.77 119.22,82.03 119.22,89.39 119.17,89.44 119.17,90.38 118.83,90.73 115.73,90.73 v1(115.35,90.35)
  BOTTOM w0.127: v1(115.35,90.35) 115.79,89.9 115.79,88.74 115.05,88 114.14,88 113.71,87.56 PR131.1
VNN_ON: length 66.1
  TOP w0.127: v1(40.97,62.1) 40.41,62.66 PR43.2 ; v1(44.23,29.13) 44.36,29.01 46.33,29.01 v1(46.79,29.47)
  TOP w0.14: U14.76 39.42,30.38 40.33,29.47 43.89,29.47 v1(44.23,29.13)
  IN3 w0.127: v1(52.94,46.83) 54.01,45.76 54.01,42.32 49.29,37.6 48.8,37.6 47.4,36.2 47.4,33.88 46.58,33.06 46.58,29.69 v1(46.79,29.47) ; v1(40.97,62.1) 40.97,62.26 43.54,64.83 46.37,64.83 v1(47.5,63.7)
  BOTTOM w0.127: v1(52.94,46.83) 52.73,46.61 51.31,46.61 50.93,46.99 50.93,48.11 51.45,48.63 51.45,53.25 51.02,53.68 51.02,55.96 48.25,58.73 48.25,59.35 47.64,59.96 47.64,60.32 46.02,61.94 42.57,61.94 41.98,62.53 41.4,62.53 v1(40.97,62.1) ; v1(47.5,63.7) 47.65,63.84 PR190.2
VNN_PVCC1: length 4.1
  TOP w0.203: PU1.12 33.38,68.33 32.54,69.16 32.49,69.16
  TOP w0.508: 32.49,69.16 v1(32.14,69.52) PC28.2
  BOTTOM w0.508: v1(32.14,69.52) 31.88,69.77 PR158.2
VNN_SENSE: length 89.9
  TOP w0.14: PR40.1 44.16,63.6 v1(44.16,62.65) 44.16,62.29 41.61,59.73 39.76,59.73 37.8,57.78 36.59,57.78 36.56,57.74 34.03,57.74 v1(32.42,59.36) 32.18,59.59 31.16,59.59 PR60.2
  IN3 w0.089: 86.62,62.73 87.01,62.34 91.03,62.34 v1(91.59,61.78)
  IN3 w0.114: 84.26,62.73 86.62,62.73
  IN3 w0.127: v1(44.16,62.65) 44.46,62.34 45.04,62.34 45.31,62.61 46.46,62.61 46.85,63 49.24,63 50.24,62.01 50.24,58.6 51.53,57.3 51.53,56.48 52.09,55.93 54.62,55.93 55.71,54.84 55.71,52.53 62.54,45.7 67.27,45.7 67.73,46.15 68.61,46.15 69.05,46.58 69.05,51.7 69.37,52.03 69.37,52.75 71.51,54.88 71.51,58.01 71.87,58.37 73.13,59.64 73.39,59.89 73.84,59.89 75.58,61.63 78.81,61.63 79.91,62.73 84.26,62.73
  BOTTOM w0.089: v1(91.59,61.78) U22.AJ41
VNNSS_SENSE: length 87.8
  TOP w0.14: PR61.2 32.43,60.11 34.28,58.26 36.34,58.26 36.37,58.3 37.59,58.3 39.54,60.25 41.39,60.25 v1(43.54,62.41) 43.54,63.34 PR39.1
  IN3 w0.089: 86.73,62.17 90.49,62.17 v1(90.88,61.78)
  IN3 w0.114: 86.73,62.17 86.7,62.2 82.87,62.2
  IN3 w0.127: v1(43.54,62.41) 44.11,61.83 45.25,61.83 45.52,62.1 46.67,62.1 47.03,62.46 49.07,62.46 49.73,61.8 49.73,58.39 51.02,57.09 51.02,56.17 51.77,55.42 54.41,55.42 55.2,54.63 55.2,52.32 62.33,45.19 67.48,45.19 67.94,45.64 68.82,45.64 69.55,46.37 69.55,51.49 69.88,51.82 69.88,52.54 72.02,54.67 72.02,57.8 72.37,58.16 72.37,58.16 73.34,59.13 73.6,59.38 74.05,59.38 75.24,60.56 77.43,60.56 77.5,60.5 78.4,60.5 80.1,62.2 82.87,62.2
  BOTTOM w0.089: v1(90.88,61.78) U22.AJ43
VR_READY_VCGI: length 3.9
  BOTTOM w0.127: PU10.7 51.95,67.76 51.47,68.25 51.47,69.72 v1(51.01,70.18) 50.86,70.03 PR156.1
VR_READY_VNN: length 2.5
  TOP w0.203: 36.86,67.48 36.86,67.37 36.24,66.75 PU1.7 ; 36.86,67.48 37.11,67.23 37.41,67.23 PR25.1 ; 36.86,67.48 v1(36.86,67.49)
VR_SVID_ALERT#_VCORE: length 63.4
  TOP w0.14: PR23.2 48.8,67.86 v1(48.8,67.8)
  IN3 w0.127: v1(52.05,58.66) 51.95,58.76 51.95,61.77 49.49,64.23 49.49,67.26 49.24,67.5 49.12,67.5 48.82,67.8 v1(48.8,67.8) 48.8,68.35 48.39,68.76 47.38,68.76 46.78,68.16 46.78,67.48 45.15,65.85 43.56,65.85 43.33,66.08 39.36,66.08 v1(39.15,65.86)
  BOTTOM w0.14: PR187.2 39.77,65.67 39.58,65.86 v1(39.15,65.86) 38.82,65.86 38.52,65.56 PR186.2 ; PR171.2 48.86,67.87 v1(48.8,67.8) ; R469.1 81.61,72.89 81.61,73 81.42,73.19 81.41,73.19 81.35,73.25 81.26,73.25 80.33,73.25 R468.2 79.66,72.69 79.37,72.4 79.37,71.61 76.16,68.41 67.88,68.41 67.01,67.53 67.01,67.12 65.44,65.56 64.81,65.56 63.34,64.08 61.47,64.08 56.09,58.7 53.12,58.7 52.88,58.47 52.24,58.47 v1(52.05,58.66)
VREF_CA_DIMM0: length 11.9
  BOTTOM w0.254: JDIM1.164 90.02,18.97 90.15,18.85
  BOTTOM w0.381: R588.2 R589.2 92.1,17.06 92.62,17.58 R587.2 C472.1 ; v1(92.87,15.04) 93.03,15.2 C472.1 ; C472.1 91.73,16.05 R603.1 C474.1 90.42,16.06 90.15,16.33 90.15,18.85
VRON: length 57.9
  TOP w0.127: v1(34.23,30.87) 35.08,30.03 35.08,28.31 35.66,27.72 37.08,27.72 37.62,27.18 U14.68 ; v1(48.09,60.15) 47.81,60.15 47.2,60.76 46.39,60.76 45.43,61.71 45.43,63.39 44.96,63.86 44.96,64.92 45.27,65.23 v1(48.42,65.23) 49.2,65.23 PR32.2
  IN3 w0.127: v1(34.23,30.87) 35.79,30.87 40.85,35.94 40.85,37.01 41.52,37.68 44.57,37.68 47.28,40.39 47.28,41.45 48.34,42.52 48.34,47.24 50.64,49.54 50.64,53.07 49.63,54.09 49.63,56.51 48.09,58.05 v1(48.09,60.15)
VRON_VCGI: length 6.8
  TOP w0.127: v1(51.15,65.79) 51.07,65.71 50.46,65.71 PR32.1 PC37.1
  BOTTOM w0.127: PU10.2 51.59,65.76 51.57,65.79 v1(51.15,65.79) 50.98,65.96 49.61,65.96 49.43,65.77 PR185.1 49.43,65.44 PR190.1
VRON_VNN: length 6.7
  TOP w0.127: PR44.1 PR43.1
  TOP w0.203: PU1.2 36.47,64.75 37.15,64.06 PC42.1 38.22,64.54 39.63,64.54 v1(39.91,64.82) PR43.1
VRTC_3P3: length 6.9
  TOP w0.508: R92.2 103.92,77.74 104.73,76.93 104.73,74.59 v1(105.09,74.23) 105.09,72.98
  BOTTOM w0.229: v1(104.03,69.45) 103.79,69.45 103.44,69.1 U22.P15
VSTBY_FSPI: length 10.5
  TOP w0.305: v1(42.78,44.12) 42.41,43.75 R256.1 R257.2 R247.2 R232.2
  IN2 w0.305: v1(38.46,45.44) 38.46,45.16 39.55,44.07 42.73,44.07 v1(42.78,44.12)
  BOTTOM w0.305: v1(38.46,45.44) 38.46,45.7 R542.2
WAKE_SRC_LAN: length 89
  TOP w0.127: Q11.3 57.82,57.82 56.5,56.5 55.07,56.5 54.74,56.83 R174.2 v1(53.4,57.74) 52.93,58.21 51.18,58.21 50.95,57.98 46.85,57.98 45.87,58.96 40.49,58.96 37.9,56.37 34.26,56.37 32.77,57.86 24.56,57.86 18.63,63.79 17.44,63.79 v1(17.3,63.93) ; Q1.3 v1(25.43,98.32) 25.79,97.97 27.47,97.97 R4.2
  IN3 w0.127: v1(25.43,98.32) 25.43,97.58 23.21,95.36 23.21,86.99 20.91,84.69 20.91,82.71 19.27,81.07 19.27,71.77 17.51,70 17.51,68.38 16.59,67.46 16.59,64.64 v1(17.3,63.93)
WAKE_SRC_WLAN: length 32.5
  TOP w0.127: R284.2 Q12.3 47.78,36.75 v1(47.78,38.96)
  IN3 w0.127: v1(47.78,38.96) 47.78,38.38 46.13,36.73 46.13,34.41 44.56,32.84 44.56,27.87 43.49,26.8 43.49,22.8 44.6,21.7 44.6,20.53 45.74,19.39 45.74,15.38 v1(45.83,15.29)
  BOTTOM w0.127: Q37.3 46,15.46 v1(45.83,15.29) 45.7,15.16 R613.1
WLAN_LED#: length 8.4
  BOTTOM w0.127: R572.2 18.45,24.1 v1(18.57,24.23) 19.54,24.23 20.1,23.67 22.15,23.67 22.65,24.17 CN10.6
WLAN_VDD:
  vias: v1(21.95,21.89)
WLANPWR#: length 7.4
  TOP w0.127: Q14.2 24.92,19.35 v1(25.79,19.35) R321.2 26.27,20.97 26.27,22.21 25.55,22.93 25.31,22.93 25.11,23.13 U14.35
WRST#: length 108.1
  TOP w0.127: U14.14 21.43,33.18 20.74,32.49 20.3,32.49 20.29,32.48 20.27,32.48 C236.1 R291.1 18.58,32.43 18.42,32.59 17.53,32.59 17.28,32.84 16.92,32.84 16.42,33.35 D17.2 v1(16.42,35.74) 16.42,36.24 17.46,37.29 17.46,54.65 v1(18.45,55.64) ; v1(63.36,11.44) 63.36,11.02 63.64,10.73 Q23.6
  IN1 w0.089: v1(63.36,11.44) 60.79,11.44 58.69,13.55 49.74,13.55 42.33,20.96 42.33,26.08 41.37,27.04 34.5,27.04 33.68,27.86 31.94,27.86 31.6,28.2 31.6,30.09 31.07,30.61 31.07,31.85 31.78,32.56 31.78,32.94 31.42,33.3 31.42,33.31 27.7,37.03 27.7,39.04 25.88,40.86 25.88,41.91 24.81,42.98 23.6,42.98 18.85,47.73 18.85,55.24 v1(18.45,55.64)
XD_CD#: length 2.1
  TOP w0.127: U11.7 163.63,40.01 163.86,39.77 TP27.1
XD_D7: length 2.4
  TOP w0.127: U11.23 164.13,46.77 TP18.1
XD_RE#: length 1.3
  TOP w0.127: TP26.1 164.88,40.18 164.63,40.43 U11.9
XDP_PRDY#: length 13.6
  BOTTOM w0.089: U22.AH55 83.92,62.75 83.3,62.13 83.3,61.6 82.91,61.21 82.58,61.21
  BOTTOM w0.14: 82.58,61.21 80.98,61.21 80.55,61.64 v1(80.55,61.77) 80.35,61.97 79.39,61.97 78.52,61.1 78.52,60.76 77.4,59.64 75.69,59.64 R511.1
XDP_PREQ#: length 15.4
  BOTTOM w0.089: U22.AJ53 86.48,62.49 86.34,62.59 86.21,62.59 86.05,62.48 86.05,62.48 85.97,62.48 85.97,62.48 85.82,62.48 85.76,62.54 84.01,62.54 83.48,62.01 83.48,61.4 83.06,60.98 82.7,60.98
  BOTTOM w0.14: 82.7,60.98 80.5,60.98 80.17,61.31 v1(79.36,61.31) 79.36,61.27 77.5,59.41 75.59,59.41 75.18,59.82 74.57,59.82 74.15,60.25 R510.1
XDP_TCK: length 19.2
  BOTTOM w0.089: 83.82,60.2 83.88,60.2 85.09,61.41 85.57,61.41 85.74,61.24 86.02,61.24 86.21,61.11 86.34,61.11 U22.AM53
  BOTTOM w0.14: 83.82,60.2 83.47,59.84 79.61,59.84 77.94,58.17 75.04,58.17 74.88,58.01 73.89,58.01 73.8,57.92 73.4,57.92 72.99,57.51 72.35,57.51 v1(71.79,56.95) 71.53,57.2 71.53,57.5 71.08,57.96 R520.1
XDP_TDI: length 20.2
  BOTTOM w0.089: U22.AJ54 86.27,62.31 84.08,62.31 83.66,61.88 83.66,61.32 83.09,60.76 82.87,60.76 ; v1(68.99,61.77) 68.99,61.52 69.63,60.88 71.29,60.88 R509.1
  BOTTOM w0.14: R509.1 71.92,60.15 72.25,59.82 73.93,59.82 74.16,59.59 75.09,59.59 75.5,59.18 77.6,59.18 79.18,60.76 82.87,60.76
XDP_TDO: length 16.8
  BOTTOM w0.089: 83.61,60.63 83.81,60.63 84.93,61.75 85.71,61.75 85.88,61.58 85.99,61.58 arc(86.04,61.58) 86.09,61.59 arc(86.12,61.62) 86.15,61.64 arc(86.19,61.66) 86.24,61.67 86.33,61.67 arc(86.37,61.67) 86.41,61.64 arc(86.44,61.62) 86.48,61.6 86.68,61.4 U22.AL53
  BOTTOM w0.14: R515.1 v1(73.13,59.1) 73.69,59.1 74.28,58.51 74.65,58.51 74.86,58.72 77.79,58.72 79.37,60.3 83.28,60.3 83.61,60.63
XDP_TMS: length 19.4
  BOTTOM w0.089: U22.AL54 86.27,61.41 85.81,61.41 85.64,61.58 85.01,61.58 83.83,60.4 83.7,60.4
  BOTTOM w0.14: R514.1 69.54,58.68 70.56,58.68 70.9,58.34 71.66,58.34 v1(71.79,58.22) 72.25,58.68 72.83,58.68 73.33,58.18 73.69,58.18 73.78,58.28 74.75,58.28 74.91,58.44 77.83,58.44 79.46,60.07 83.37,60.07 83.7,60.4
XDP_TRST#: length 21
  BOTTOM w0.089: 82.96,60.53 83.12,60.53 83.83,61.24 83.83,61.81 84.14,62.12 86.07,62.12 86.09,62.1 86.15,62.05 86.35,61.85 86.47,61.85 86.48,61.85 U22.AK53 ; 68.36,60.88 69.12,60.88 69.76,60.25 R508.1
  BOTTOM w0.127: 68.36,60.88 68.33,60.88 v1(68.21,60.76)
  BOTTOM w0.14: R508.1 70.6,59.54 73.89,59.54 74.06,59.36 74.96,59.36 75.37,58.95 77.7,58.95 79.27,60.53 82.96,60.53
XTAL1: length 6.9
  TOP w0.14: U3.28 30.44,86.28 30.32,86.16 30.32,85.72 C21.2 30.32,84.83 30.32,83.93 30.64,83.61 30.64,82.18 30.39,81.92 Y1.1
XTAL2: length 5.5
  TOP w0.14: U3.29 30.84,86.34 31.15,86.03 31.15,85.54 31.4,85.29 C22.2 31.28,85.27 30.84,84.84 30.84,84.15 31.16,83.83 31.16,83.2 Y1.3
XTAL192_IN: length 8.7
  BOTTOM w0.14: Y3.1 116.08,67.75 C394.2 114.47,68.5 R479.2 113.32,68.11 113.32,68.08 112.26,68.08 111.35,67.17 110.2,67.17 109.66,67.71 U22.U2
XTAL192_OUT: length 10.4
  BOTTOM w0.14: U22.T1 109.72,68.16 110.14,67.74 111.28,67.74 112.05,68.5 R479.1 113.35,68.92 115.17,68.92 C390.2 115.72,68.38 117.89,68.38 118.35,68.84 Y3.3
N17893945: length 4.4
  TOP w0.127: TP3.1 28.62,84.29 C24.1 28.62,85.09 30.04,86.52 U3.27
N17893959: length 5.5
  TOP w0.127: TP2.1 26.7,84.62 C23.1 26.71,84.89 27.46,85.65 28.41,85.65 29.24,86.48 U3.25
N17893963: length 6.4
  TOP w0.102: 27.21,83.77 27.36,83.62
  TOP w0.127: U3.26 29.64,86.55 28.48,85.39 27.59,85.39 27.21,85.01 27.21,83.77 ; 27.36,83.62 TP4.1
N17894030: length 7.1
  TOP w0.508: v1(36.99,95.3) 36.61,95.3 36.47,95.16 C5.2
  BOTTOM w0.508: U20.10 36.48,95.62 36.81,95.3 v1(36.99,95.3) ; U20.7 v1(36.98,92.62) ; U20.4 v1(36.98,89.62) ; U20.1 v1(36.98,86.62)
N17899062: length 1.7
  TOP w0.203: C284.2 174.99,19.39 U16.39
N17899068: length 7.6
  TOP w0.127: U16.35 177.68,21.58 177.03,22.24 176.47,22.24 176.35,22.36 176.35,24.27 175.95,24.66 175.06,24.66 v1(174.66,25.07) 174.4,25.07 173.9,24.56 C266.2
N17899074: length 3.8
  TOP w0.203: U16.37 175.31,21.26 v1(175.11,21.26) 175.11,21.46 174.73,21.84 174.73,21.98 C266.1
N17899116: length 2.2
  TOP w0.127: C268.1 176.94,22.73 178.08,21.59 U16.34
N17899118: length 3.3
  TOP w0.127: C287.1 185.44,18.71 v1(185.58,18.85)
  TOP w0.203: U16.19 183.88,18.19 184.4,18.71 C287.1
N17899208: length 1.9
  TOP w0.127: TP42.1 175.55,14.83 175.91,15.19 175.91,15.52 176.17,15.79 U16.48
N17899770: length 2.5
  TOP w0.127: C311.1 179.43,12.5 179.43,13.33 v1(179.48,13.38) 179.48,13.56 179.68,13.76 U16.7
N17900044: length 3.7
  TOP w0.127: v1(178.21,32.05) 178.09,31.93 R294.2
  TOP w0.508: R294.2 R293.2 174.61,31.93 U15.5
N17900328: length 78.8
  TOP w0.127: R363.2 v1(185.83,10.67) ; 170.09,3.35 173.01,3.35 173.54,3.89 D32.1 173.54,5.76 174.56,6.78 v1(174.78,6.78) ; D31.1 139.69,27.95 139.35,27.61
  TOP w0.14: 170.09,3.35 169.61,2.87 150.22,2.87 149.82,3.27 149.82,4.67 151.16,6.02 151.16,8.76 151.82,9.42 151.82,12.52 150.63,13.71 150.63,16.21 149.77,17.07 147.52,17.07 146.31,18.29 144.14,18.29 140.6,21.83 139.23,21.83 138.97,22.09 138.97,27.23 139.35,27.61
  BOTTOM w0.127: v1(174.78,6.78) 175.29,7.29 175.29,8.3 174.91,8.69 174.91,9.7 175.29,10.08 179.4,10.08 180.6,11.29 185.21,11.29 v1(185.83,10.67)
N18674815: length 3.7
  BOTTOM w0.127: Q30.2 117.28,87.79 117.01,88.06 R437.1 117.01,88.64 116.7,88.95 116.57,88.95 v1(116.24,89.28) 116.24,89.45 R396.2
N19419989: length 12.6
  BOTTOM w0.127: v1(28.14,34.55) D41.1 ; D41.1 30.08,34.55 30.22,34.41 SW1.3 30.95,35.48 31.4,35.93 31.4,38.91 30.95,39.36 SW1.4 ; D41.1 29.14,34.31 29.88,33.58 29.88,32.82 R554.2
N19785488: length 7.7
  TOP w0.127: Q18.3 81.24,12.75 R353.1 83.59,14.02 84.49,14.02 Q19.2 85.63,15.29 v1(84.49,16.43)
N19867916: length 2.1
  TOP w0.254: v1(45.36,51.73) R195.1
  BOTTOM w0.254: v1(45.36,51.73) 45.24,51.61 U28.4
N19868095: length 3.2
  BOTTOM w0.127: U28.13 41.57,48.08 41.74,47.9 42.21,47.9 v1(42.82,47.29) R539.2
N19868357: length 2.7
  TOP w0.254: v1(45.45,53.92) 45.08,54.29 R184.1
  BOTTOM w0.254: v1(45.45,53.92) 44.63,53.11 U28.1
N19868418: length 3.3
  BOTTOM w0.127: R526.1 39.91,56.82 39.4,57.33 v1(39.4,57.58) 40.16,58.34 U23.5
N20280006: length 2.8
  TOP w0.508: PR59.2 156.11,59.6 v1(155.99,59.49) 156.5,58.98 PQ7.3
N20280012: length 3.1
  BOTTOM w0.508: PR264.2 137.19,5.14 v1(137.19,5.38) PQ24.3
N22956619: length 3.8
  TOP w0.127: v1(108.24,86.66) 108.62,87.04 109.72,87.04 PR1.2
  TOP w0.508: PR1.2 109.85,85.13 PQ1.3
N24795992: length 4.7
  TOP w0.203: R331.1 185.52,20.37 v1(184.94,20.37) 184.56,20.37 184.06,19.86 184.06,18.85 183.8,18.59 U16.20
N25027434: length 4.4
  BOTTOM w0.127: R584.2 v1(82.33,17.83) 82.75,17.41 83.57,17.41 C468.1 84.49,17.83 84.77,17.55 Q36.2
N25929013:
  vias: v1(20.99,80.57)
N25929051: length 4.4
  TOP w0.127: Q3.2 v1(19.84,76.25) 20.61,75.49 C75.2 R89.2 R93.1
N25929294: length 1.5
  TOP w0.14: U16.4 178.48,14.09 TP43.1
N26762117: length 10.5
  TOP w0.127: R190.2 57.4,52.88 57.99,52.28 59.71,52.28 60.16,52.73 v1(61.86,52.73) 62.74,52.73 v1(62.91,52.91) ; R190.2 56.16,52.1 R197.2 ; R190.2 56.94,53.4 57.36,53.82 D6.2
  BOTTOM w0.14: U26.K5 63.39,52.3 62.91,52.78 v1(62.91,52.91)
N27652896: length 5.7
  TOP w0.127: Q23.2 64.29,8.56 64.42,8.69 64.8,8.69 64.94,8.54 Q23.3 64.94,7.27 v1(65.56,6.65) 65.95,7.03 R382.2 C324.1
N27652903: length 2.9
  TOP w0.127: R382.1 R367.2 R368.2 v1(67.84,9.44)
N30146783: length 4.7
  BOTTOM w0.127: Q31.6 Q31.5 78.47,82.01 78.26,82.22 77.5,82.22 77.1,81.81 77.1,80.74 v1(76.97,80.62) 76.97,80.02 R432.1
N30208544: length 3.6
  TOP w0.127: R385.1 156.93,4.74 156.68,4.49 v1(156.39,4.49)
  TOP w0.508: Q28.2 159.15,4.74 R386.2 R385.1
N30244659: length 6.3
  TOP w0.127: R351.1 54.77,12.88 55.28,13.38 55.28,14.02 55.4,14.15 56.29,14.15 56.42,14.02 Q16.2 56.42,11.99 v1(56.55,11.86) 57.07,12.38 Q16.3
N30245063: length 4.3
  TOP w0.102: 53.78,12.72 53.75,12.75 R350.1
  TOP w0.127: R350.1 53.36,12.87 53.1,13.13 Q15.3 52.75,12.51 52.61,12.37 52.23,12.37 52.1,12.5 Q15.2 ; 53.78,12.72 v1(54.52,11.99)
N30246849: length 3.6
  TOP w0.127: R371.1 53.42,9.1 Q26.6 54.25,9.81 v1(54.52,10.08) 54.9,9.7 Q26.5
N30273822: length 1.1
  BOTTOM w0.508: R518.1 C410.2
N30274264: length 3.7
  TOP w0.14: R144.1 v1(135.03,61.01) 135.03,58.56 U9.E9
N30274422: length 5.1
  TOP w0.14: R242.1 131.85,43.73 131.85,43.51 v1(132.26,43.1) 132.87,43.1 134.53,41.45 134.53,40.78 U13.E9
N30274704: length 9.1
  BOTTOM w0.14: R531.1 128.41,51.75 128.79,51.75 130.35,50.19 134.2,50.19 134.48,50.47 134.48,51.61 U25.E9
N30274864: length 4.5
  BOTTOM w0.127: v1(134.53,30.78) 133.63,30.78 R555.1
  BOTTOM w0.14: v1(134.53,30.78) 134.68,30.94 134.68,34.03 U30.E9
N30282349:
  vias: v1(113.04,30.22) v1(113.04,29.56) v1(113.7,29.89)
N30283102: length 1.9
  BOTTOM w0.127: C470.2 v1(97.19,17.58)
  BOTTOM w0.381: R594.2 C470.2
N30283376: length 3
  TOP w0.14: TP37.1 90.43,28.78 v1(90.43,30)
  BOTTOM w0.14: JDIM1.165 90.28,29.84 v1(90.43,30)
N30283378: length 3.1
  TOP w0.127: TP41.1 88.3,22.27 88.81,22.27 v1(89.06,22.02)
  BOTTOM w0.102: v1(89.06,22.02) 89.53,21.55 JDIM1.162
N30318989:
  vias: v1(145.45,73.07) v2(144.18,75.03) v2(144.94,75.03) v2(144.94,74.22) v2(145.7,75.03)
N30318999: length 29.9
  IN1 w0.254: v1(124.9,79.94) 124.99,79.94 125,79.93 130.21,79.93 131.62,78.52 131.62,76.71 133.2,75.13 133.2,74.09 133.46,73.84 137.76,73.84 138.17,73.43 141.61,73.43 142.19,72.85 145.3,72.85 147.56,75.11 v1(147.61,75.11)
  BOTTOM w0.254: v1(147.61,75.11) 148.23,75.11 PR141.1 PC139.2
N30319333: length 1.5
  BOTTOM w0.508: PC118.1 PR132.2
N30319351: length 2.3
  TOP w0.508: PC11.2 141.76,80.82 v1(141.51,81.08) 142.25,81.81 PR5.1
N30322034: length 8.6
  TOP w0.254: PR117.2 v1(112.3,8.56)
  BOTTOM w0.254: v1(112.3,8.56) 112.3,9.12 114.02,10.84 115.71,10.84 116.87,12.01 116.87,12.7 117.1,12.93 v1(117.71,12.93)
  vias: v1(116.62,13.51)
N30322038:
  vias: v1(109.25,14.02)
N30322042: length 1.8
  TOP w0.127: v1(112.31,6.35) 112.3,6.36 PR117.1
  TOP w0.254: PR116.1 PR117.1
N30322054: length 3.8
  TOP w0.127: v1(115.06,9.77) 115.09,9.74 PC98.2
  TOP w0.254: PR119.1 115.09,8.69 PC98.2 114.77,9.26 PU3.1
N30322056: length 2.9
  TOP w0.127: PR120.1 115.35,6.48 v1(115.22,6.35)
  TOP w0.254: PR118.2 PR119.2 PR120.1
N30322070: length 4.4
  TOP w0.127: PR116.2 111.28,7.92 110.78,7.42 110.78,6.65 111.03,6.4 v1(111.03,6.35)
  TOP w0.254: PU3.6 110.27,8.98 PR115.1 PR116.2
N30322095: length 2.5
  TOP w0.127: PR109.2 109,10.46 v1(109.13,10.59) 109.51,10.21 PU3.5
N30371514: length 11.1
  TOP w0.127: v1(40.38,42.21) 40.38,42.56 40.93,43.1 R256.2 ; v1(35.25,42.56) 35.25,42.5 34.87,42.12 33.21,42.12 33.04,41.95 C217.1 33.11,41.64 U14.106
  IN2 w0.127: v1(35.25,42.56) 35.41,42.41 40.19,42.41 v1(40.38,42.21)
