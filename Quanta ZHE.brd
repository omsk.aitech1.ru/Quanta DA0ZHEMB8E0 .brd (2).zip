# Allegro board Quanta ZHE.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_TXP2_LAN_C: length 9.2
  BOTTOM w0.089: 107.14,75.72 107.14,75.7 107.08,75.64 107.08,75.34 107.18,75.24 107.18,74.84 107.04,74.7 106.94,74.7 106.77,74.61 106.6,74.43 106.6,74.28 U22.C9
  BOTTOM w0.14: 107.14,75.72 107.14,75.92 108.89,77.67 109.73,77.67 111.67,79.61 111.67,80.06 C369.2
PCIE_TXP3_WLAN: length 178.8
  IN3 w0.127: v1(109.76,81.84) 109.51,82.09 109.51,84.22 106.61,87.11 105.23,87.11 104.74,86.63 91.74,86.63 91.12,87.25 89.56,87.25 89.11,86.79 86.17,86.79 84.59,88.36 77.43,88.36 76.31,89.48 73.24,89.48 70.87,87.11 65.56,87.11 64.06,85.61 60.17,85.61 59.67,85.11 54.56,85.11 50.92,81.47 50.6,81.47 49.09,79.96 36.6,79.96 35.64,78.99 29.89,78.99 28.1,77.21 28.1,66.96 26.22,65.08 26.22,61.48 24.62,59.88 24.62,56.92 22.49,54.79 22.49,48.46 19.21,45.18 19.21,38.02 19.98,37.25 19.98,31.36 22.24,29.1 22.24,27.44 23.58,26.1 23.58,25.74 23.58,25.27 24.92,23.93 24.92,22.86 24.67,22.61 24.67,22.02 29.57,17.12 32.49,17.12 33.57,16.03 33.57,15.53 32.69,14.65 30.13,14.65 27.47,11.99 27.47,11.57 v1(27.22,11.32)
  BOTTOM w0.14: v1(109.76,81.84) 109.68,81.76 109.68,81.29 C367.2 ; v1(27.22,11.32) 27.46,11.57 27.46,12.24 29.37,14.14 29.37,14.52 R597.2
PCIE_TXP3_WLAN_C: length 7.6
  BOTTOM w0.089: 106.36,75.87 106.36,75.85 106.32,75.8 106.32,75.56 106.15,75.39 106.15,74.87 106.11,74.79 106.09,74.78 U22.C10
  BOTTOM w0.14: 106.36,75.87 106.36,76.33 109.64,79.61 109.64,80.06 C367.1
PCIE_TXP3_WLAN_NGFF: length 4.9
  BOTTOM w0.14: R597.1 29.52,15.96 29.52,16.33 v1(29.04,16.81) 29.52,17.3 29.52,17.7 30.02,18.2 30.02,18.53 29.9,18.65 CN10.35
PCIE_WAKE2_N: length 56.6
  TOP w0.127: R169.2 54.63,57.56 54.97,57.56 55.33,57.2 55.79,57.2 56.67,58.09 56.67,60.02 59.18,62.52 59.18,66.05 59.98,66.85 65.56,66.85 66.15,67.44 v1(69.65,67.44)
  IN1 w0.089: v1(90.58,72.94) 89.48,74.04 89.48,75.77 89.11,76.14 88.15,76.14 87.93,76.36 86.2,76.36 85.51,77.04 85.51,78.11 84.48,79.15 81.84,79.15 80.4,77.7 80.4,76.01 79.97,75.58 79.97,72.21 76.38,68.61 70.83,68.61 v1(69.65,67.44)
  BOTTOM w0.089: U22.F45 90.53,72.94 v1(90.58,72.94)
PCIE_WAKE3_N: length 83.9
  TOP w0.127: R281.2 44.7,38.56 46.67,38.56 46.95,38.28 46.95,36.68 Q12.1 45.14,36.6 v1(44.69,36.6)
  IN1 w0.089: v1(44.69,36.6) 44.82,36.6 45.94,37.72 45.94,43.64 46.31,44.01 46.31,47.95 47.15,48.79 51.42,48.79 55.36,52.72 55.36,54.04 57.31,55.99 57.31,59.13 63.06,64.89 64.67,64.89 66.21,66.42 69.56,66.42 71.52,68.38 76.42,68.38 80.16,72.13 80.16,75.5 80.59,75.93 80.59,77.62 81.92,78.95 84.4,78.95 85.32,78.03 85.32,76.97 85.7,76.59 86.12,76.17 87.75,76.17 v1(88.18,75.74)
  BOTTOM w0.089: U22.D50 88.49,74.13 88.49,75.44 88.19,75.74 v1(88.18,75.74)
PCIE_WAKE#_R: length 20.9
  IN3 w0.127: v1(44.3,18.16) 42.19,16.05 38.26,16.05 36,18.31 v1(35.59,18.31)
  BOTTOM w0.127: v1(35.59,18.31) 35.23,18.31 34.9,18.65 CN10.55 ; Q37.1 47.23,15.44 46.39,14.6 44.65,14.6 R613.2 44.1,15.17 R592.2 44.93,17.25 R585.1 44.35,18.21 v1(44.3,18.16)
PCLK_TPM: length 117.4
  IN1 w0.089: v1(44.47,60.47) 44.72,60.72 45.51,60.72 45.8,60.42 45.8,60.03 46.12,59.72 48.4,59.72 50.89,62.21 53.08,62.21 54.99,64.12 56.04,64.12 56.97,65.05 57.8,65.05 60.74,67.99 63.72,67.99 64.02,68.29 64.64,68.29 68.2,71.84 68.2,78.41 70.2,80.41 70.2,84.68 69.61,85.27 69.61,85.69 72.63,88.71 81.26,88.71 86.73,83.23 90.12,83.23 91.83,81.52 92.53,81.52 v1(93.01,82)
  BOTTOM w0.089: v1(93.01,82) 93.01,82.35 C352.1 93.48,82.36 93.48,81.81 93.2,81.53 93.07,81.53 92.74,81.2 92.74,80.19 92.54,79.98 92.54,79.54 92.68,79.4 92.68,78.85 R440.1
  BOTTOM w0.127: v1(44.47,60.47) 44.37,60.56 42.26,60.56 42.03,60.33 39.65,60.33 38.29,58.97 35.71,58.97 34.6,57.86 28.75,57.86 26.07,55.18 26.07,51.38 27.09,50.36 27.73,49.72 28.75,48.7 34.72,48.7 C416.1
  BOTTOM w0.14: C416.1 36.04,50.02 37.56,50.02 38.14,50.61 U28.19
PD#: length 13.4
  TOP w0.127: R346.1 172.38,14.4 R348.2 169.06,14.41 v1(168.69,14.78) 167.04,16.43 D27.2 D26.2
  TOP w0.14: R346.1 173.8,14.83 175.21,14.83 175.67,15.29 175.67,16.05 175.81,16.19 U16.47
PERSTB: length 3.5
  TOP w0.14: R23.2 R22.2 26.71,90.31 27.03,90.63 27.86,90.63 28.05,90.44 U3.19
PHASE_VCGI: length 25.7
  TOP w0.508: v2(53.25,70.66) 53.21,70.63 PC26.2 ; v2(54.64,77.27) v1(54.64,75.87) 54.64,74.14 55.07,73.71 PR12.1
  IN1 w0.635: v2(54.64,77.27) 53.25,75.87 v2(53.25,70.66)
  BOTTOM w0.178: PR140.1 64.18,77.37 60.18,77.37 59.93,77.37 58.83,78.46 58.83,80.03 58.55,80.31 PL2.1
  BOTTOM w0.203: PU10.10 53.91,69.34 53.52,69.73 53.52,70.02
  BOTTOM w0.508: 53.52,70.02 53.52,70.38 v2(53.25,70.66)
PHASE_VNN: length 11.5
  TOP w0.178: PR10.2 41.94,75.11 v1(42.07,74.98)
  TOP w0.203: PU1.10 34.18,68.9 v2(33.94,69.14)
  IN1 w0.635: v1(37.22,73.18) 36.55,72.5 36.55,71.25 35.44,70.14 34.95,70.14 v2(33.94,69.14)
  BOTTOM w0.178: PL4.1 v1(42.07,74.98)
  vias: v1(36.74,70.15)
PLTRST#: length 162.9
  TOP w0.14: v1(25.28,88.52) 25.28,88.84 25.93,89.5 R22.1 ; v1(55.38,50.72) 55.22,50.89 55.22,53.56 54.74,54.04 D6.1 53.75,54.41 52.23,55.93 51.41,55.93 51.15,56.2 45.03,56.2 44.42,56.8 42.31,56.8 39.77,54.26 v1(39.25,54.26) 38.6,53.6 38.6,52.59 37.66,51.66 36.9,51.66 34.75,49.51 33.9,49.51 32.7,48.31 28.1,48.31 22.9,53.51 19.57,53.51 18.45,52.38 v1(18.45,52.37) ; R460.1 R638.2 61.99,63.67 R461.1 61.02,63.26 61.02,62.78 60.79,62.55 U34.4 59.86,62.55 58.71,61.39 58.71,59.26 v1(59.24,58.72) ; U14.22 23.43,29.98 23.55,30.1 28.31,30.1 29.2,30.99 31.45,30.99 31.66,30.78 v1(31.74,30.78)
  IN1 w0.089: v1(59.24,58.72) 58.22,57.71 58.22,55.61 56.27,53.66 56.27,52.25 55.38,51.36 v1(55.38,50.72) ; v1(38.26,49.52) 39.22,50.48 39.22,54.22 v1(39.25,54.26)
  IN3 w0.127: v1(25.28,88.52) 21.29,84.53 21.29,82.55 19.65,80.92 19.65,71.61 19.21,71.16 19.21,66.7 18.36,65.86 18.36,58.42 17.46,57.52 17.46,53.36 v1(18.45,52.37)
  BOTTOM w0.14: v1(18.45,52.37) 18.83,51.99 24.51,51.99 25.03,51.47 25.03,50.95 26.35,49.63 27,48.98 28.32,47.66 28.91,47.66 31.02,45.55 31.02,43.15 31.54,42.63 32.03,42.63 32.94,41.71 34.05,41.71 34.06,41.72 34.26,41.72 34.27,41.71 35.51,41.71 36.93,40.29 36.93,37.43 35.41,35.91 35.41,33.45 34.88,32.92 32.72,32.92 31.74,31.94 v1(31.74,30.78) R560.1 ; U28.17 38.35,49.61 v1(38.26,49.52)
PLTRST#_2: length 18.3
  TOP w0.14: R287.2 v1(42.07,33.96)
  IN1 w0.089: v1(42.07,33.96) 41.69,33.58 40.21,33.58 40.2,33.57 39.87,33.57 39.87,33.58 38.77,33.58 38.01,32.82 37.24,32.82 v1(36.61,33.45)
  BOTTOM w0.14: CN10.52 34.15,27.88 33.86,28.17 33.2,28.17 32.29,29.08 32.03,29.08 R560.2 32.29,29.93 32.29,31.93 32.88,32.52 35.17,32.52 36.1,33.45 v1(36.61,33.45)
PMON: length 197.3
  TOP w0.127: PU1.19 30.71,65.15 30.51,64.95 30.51,64.18 PR42.1 30.6,63.68 v1(30.64,63.63)
  TOP w0.178: PR110.2 PC100.2 PR113.1 v1(149.13,7.8)
  IN1 w0.089: v1(18.45,55) 17.3,53.86 17.3,48.74 23.7,42.34 23.7,39.69 24.44,38.95 24.44,38.28 24.96,37.76 24.96,36.99 25.39,36.56 25.39,30.56 26.34,29.6 26.34,26.8 26.51,26.64 26.51,18.42 33.03,11.9 33.03,10.46 33.52,9.97 40.59,9.97 40.99,9.58 58.55,9.58 59.86,8.27 65.37,8.27 65.96,7.68 82.58,7.68 83.6,8.7 110.17,8.7 110.71,8.16 118.82,8.16 121.63,10.97 132.82,10.97 136.93,6.86 147.01,6.86 147.94,7.8 v1(149.13,7.8)
  BOTTOM w0.127: v1(18.45,55) 19.63,56.18 25.97,56.18 28.42,58.63 28.42,63.1 28.95,63.63 v1(30.64,63.63)
PMU_RSTBTN#: length 64.2
  TOP w0.14: R194.1 50.83,52.25 52.29,50.79 53.05,50.79 v1(53.5,50.34) 54.52,49.33 55.4,49.33 v1(55.79,48.94)
  IN1 w0.089: v1(55.79,48.94) 57.29,50.45 57.29,53.7 58.91,55.32 58.91,57.24 63.66,62 65.03,62 67.66,64.63 69.82,64.63 71.39,66.2 76.28,66.2 78.86,68.78 80.16,68.78 81.39,70 81.39,70.67 83.26,72.54 83.27,72.54 84.42,73.69 84.42,74.9 81.93,77.38 v1(81.19,77.38)
  BOTTOM w0.089: 86.85,75.52 87.28,75.09 87.28,74.74 U22.C51
  BOTTOM w0.14: 86.85,75.52 85.73,75.52 85.38,75.87 83.24,75.87 82.79,76.33 81.87,76.33 81.68,76.51 C377.2 v1(81.19,77.38) 81.15,77.38 80.69,76.92 R452.2
PMU_SLP_S0#: length 58.4
  TOP w0.127: R201.1 v1(50.96,51.23) 51.28,51.23 53.69,48.82 v1(54.98,48.82)
  IN1 w0.089: v1(83.03,75.36) 82.09,75.36 81.58,75.87 81.07,75.87 80.56,75.37 80.56,71.99 76.57,67.99 71.67,67.99 69.72,66.04 66.37,66.04 64.83,64.51 63.22,64.51 61.55,62.84 61.55,61.96 60.99,61.39 60.63,61.39 60.04,60.8 60.04,60.44 57.69,58.09 57.69,55.83 55.74,53.88 55.74,52.56 54.52,51.35 54.52,49.28 v1(54.98,48.82)
  BOTTOM w0.089: 86.47,75.29 86.67,75.09 86.67,75.08 86.67,74.8 U22.C52
  BOTTOM w0.14: 86.47,75.29 85.5,75.29 85.15,75.64 83.3,75.64 v1(83.03,75.36) 82.52,75.87 R459.2
PMU_SUSCLK: length 1.5
  TOP w0.14: v1(87.94,72.81) 88.39,72.36 TP7.1
  BOTTOM w0.089: v1(87.94,72.81) 88.39,72.36 TP7.1
PRE_SEL: length 3.4
  TOP w0.127: R28.1 116.37,86.82 115.98,86.43 115.98,85.8 116.26,85.52 U6.27
PROCHOT_EC: length 10.7
  TOP w0.14: R295.2 18.06,30.27 18.65,30.86 v1(18.65,31.21) 18.94,31.51 20.95,31.51 21.42,31.98 U14.17 23.81,31.98 24.62,32.79 v1(24.77,32.79)
  BOTTOM w0.14: v1(24.77,32.79) 23.65,33.91 Q34.2
PTP_PWR_EN#: length 79.8
  TOP w0.14: U14.125 25.51,39.17 25.84,38.84 25.84,38.22 26.1,37.96 28.55,37.96 29.46,38.88 v1(29.77,38.88)
  IN1 w0.089: v1(79.66,18.72) 79.66,18.14 81.33,16.47 81.33,16.14 81.1,15.9 72.31,15.9 71.41,16.81 60.9,16.81 59.42,15.33 49.06,15.33 43.09,21.31 43.09,26.4 41.5,27.99 35.47,27.99 34.82,28.64 34.82,31.39 30.13,36.08 30.13,38.28 29.77,38.64 v1(29.77,38.88)
  BOTTOM w0.127: v1(79.66,18.72) 79.66,18.08 v1(79.79,17.96) 79.92,17.83 R584.1
PWRLED#: length 118.2
  TOP w0.127: R8.1 R9.1 v1(69.75,95.68) 70.61,96.54 v1(70.82,96.54) ; U14.24 23.83,29.18 v1(23.91,29.26)
  IN1 w0.089: v1(70.82,96.54) 70.4,96.12 70.4,95.58 62.95,88.14 57.99,88.14 56.21,86.36 54.78,86.36 47.8,79.38 21.32,79.38 20.1,78.15 20.1,78.13 15.32,73.35 15.32,49.91 23.13,42.11 23.13,30.34 23.91,29.56 v1(23.91,29.26)
R_SPK+:
  vias: v1(168.82,10.84) v1(169.45,10.84) v1(174.2,16.05) v1(174.83,16.05)
R_SPK+_CN:
  vias: v1(168.43,6.53) v1(169.07,6.53)
R_SPK-:
  vias: v1(166.91,10.84) v1(167.55,10.84) v1(174.2,16.71) v1(174.83,16.71)
R_SPK-_CN:
  vias: v1(167.04,6.53) v1(167.67,6.53)
RAM_ID0: length 36.9
  TOP w0.127: R200.2 68.1,51.23 R199.1 66.84,50.48 65.18,48.82 v1(64.8,48.82)
  IN1 w0.14: v1(87.27,64.5) 86.83,64.5 85.37,63.04 81.99,63.04 81.15,62.2 80.98,62.2 80.41,61.63 80.41,60.04 73.26,52.88 68.87,52.88 67.22,51.23 65.31,51.23 64.7,50.62 64.7,48.92 v1(64.8,48.82)
  BOTTOM w0.089: v1(87.27,64.5) 87.38,64.37 87.56,64.17 U22.AE51
RAM_ID1: length 27.1
  TOP w0.127: R176.1 R171.2 v1(67.91,57.19)
  IN1 w0.114: v1(87.26,66.31) 86.9,66.31 85.33,64.74 84.61,64.74 84.02,64.15 81.56,64.15 80.7,63.29 80.52,63.29 79.2,61.97 79.2,60.5 76.54,57.85 73.91,57.85 73.85,57.79 73.48,57.79 73.05,57.36 72.46,57.36 71.71,58.11 68.84,58.11 v1(67.91,57.19)
  BOTTOM w0.089: U22.AA51 87.56,66 v1(87.26,66.31)
RAM_ID2: length 27.2
  TOP w0.127: R165.2 70.02,58.6 71.41,58.6 R166.1 71.92,58.84 v1(72.8,57.96)
  IN1 w0.114: v1(90.15,66.47) 89.52,67.1 86.89,67.1 86.51,66.72 85.79,66.01 84.43,66.01 84.34,65.91 82.98,64.56 81.39,64.56 80.56,63.73 80.38,63.73 78.79,62.14 78.79,60.67 76.37,58.25 73.74,58.25 73.68,58.2 73.04,58.2 v1(72.8,57.96)
  BOTTOM w0.089: U22.AA46 90.15,66.34 v1(90.15,66.47)
RAM_ID3: length 29.7
  TOP w0.127: v1(69.88,53.9) R186.1 R192.2
  IN1 w0.114: v1(91.59,64.57) 91.09,65.07 90,65.07 89.87,65.2 86.71,65.2 85.6,64.09 84.88,64.09 84.27,63.48 81.81,63.48 80.96,62.64 80.8,62.64 79.92,61.76 79.92,60.3 73.51,53.9 v1(69.88,53.9)
  BOTTOM w0.089: v1(91.59,64.57) U22.AE41
RAM_ID4: length 32.9
  TOP w0.127: R185.1 R191.2 66.7,52.13 v1(66.76,52.07)
  IN1 w0.114: v1(90.13,64.59) 90.05,64.59 89.65,64.99 86.99,64.99 85.27,63.27 81.89,63.27 81.05,62.43 80.89,62.43 80.19,61.72 80.19,60.13 73.17,53.11 68.61,53.11 68.33,53.39 67.72,53.39 66.76,52.42 v1(66.76,52.07)
  BOTTOM w0.089: U22.AE44 90.52,64.2 v1(90.13,64.59)
RAM_ID5: length 24.9
  TOP w0.127: v1(77.25,60.12) 77.25,59.61 v1(76.87,59.23) 76.74,59.1 R167.2 75.25,58.49 74.27,58.49 73.83,58.94 R164.1
  IN1 w0.114: v1(77.25,60.12) 77.45,60.32 77.45,61.44 80.2,64.18 80.4,64.18 81.21,64.99 82.81,64.99 84.16,66.34 84.25,66.44 85.61,66.44 86.71,67.53 89.98,67.53 90.61,66.9 91.07,66.9 91.33,66.64 91.33,65.71 v1(91.55,65.48)
  BOTTOM w0.089: v1(91.55,65.48) 91.95,65.09 U22.AC41
REGN6V: length 19
  TOP w0.178: 141,11.36 141.63,11.36 141.75,11.24 PU2.24
  TOP w0.254: 141,11.36 140.62,11.74 140.62,12.33 140.33,12.62 140.11,12.62 139.95,12.78 PC87.1
  TOP w0.508: PR127.1 144.69,4.37 145.11,3.94 v1(145.11,3.93) ; PC87.1 v1(140.75,13.38)
  BOTTOM w0.508: v1(140.75,13.38) 140.24,12.88 140.24,5.54 141.15,4.62 144.56,4.62 145.11,4.07 145.11,3.94 v1(145.11,3.93)
REGOUT:
  vias: v1(28.23,87.3) v1(28.35,86.41) v1(28.73,86.92)
RF_EN: length 11.4
  TOP w0.127: U14.66 36.27,26.38 34.56,28.09 34.56,29.29 v1(33.41,30.44)
  BOTTOM w0.127: R559.1 C444.2 34.96,31.04 v1(34.32,31.67) 33.41,30.76 v1(33.41,30.44)
RF_EN_C: length 3.1
  BOTTOM w0.127: R559.2 36.1,29.51 v1(35.59,29.01) 35.15,28.56
  BOTTOM w0.14: CN10.56 35.15,28.56
RF_KILL#_R: length 28.4
  IN1 w0.114: v1(90.88,65.53) 90.75,65.53 90.32,65.96 89.8,65.96 89.47,65.63 86.53,65.63 85.42,64.52 84.7,64.52 84.11,63.94 81.65,63.94 80.79,63.07 80.62,63.07 79.41,61.87 79.41,60.41 74.26,55.26 72.5,55.26 71.91,55.85 71.91,56.44 v1(70.9,57.45)
  BOTTOM w0.089: v1(90.88,65.53) U22.AC43
  BOTTOM w0.127: R523.1 70.39,56.95 v1(70.9,57.45)
RING2: length 33.4
  TOP w0.203: v1(183.55,16.81) 183.55,16.97 183.12,17.39 U16.17
  IN2 w1.016: 170.21,42.09 170.21,38.02 173.25,34.98 177.21,34.98 177.96,34.23 177.96,28.95 181.13,25.78 181.13,23.43 182.66,21.91 182.66,17.45
  vias: v1(169.7,47.5) v1(169.7,46.86) v1(170.26,47.19) v1(183.55,16.18)
RING2_R:
  vias: v1(169.83,49.63) v1(170.44,49.82) v1(170.72,49.2)
RREF: length 2.5
  TOP w0.305: R233.2 161.7,45.26 v1(161.83,45.39) 161.83,45.01 162.36,44.48 U11.1
RSET: length 4.6
  TOP w0.203: 31.83,86.76 31.64,86.96 U3.31
  TOP w0.254: R40.2 v1(32.54,84.38) 32.11,84.81 32.11,86.49 31.83,86.76
RSMRST#: length 4
  TOP w0.127: 30.71,42.02 R263.1 30.01,42.45 29.52,41.96 v1(29.52,41.86)
  TOP w0.14: U14.112 30.71,42.02
RTC_RST#: length 201.1
  TOP w0.508: R358.2 C301.1 69.5,13.25 J1.1 v1(69.5,15.04) v1(69.5,16.18) ; 97.59,84.9 97.59,83.29 96.17,81.87 96.17,78.54 96.77,77.94 96.77,76.74 97.87,75.64 97.87,74.71 98.74,73.84 v1(98.74,73.53) ; 97.59,84.9 97.59,88.22 96.6,89.2 96.37,89.2 95.84,89.74 95.84,91.79 96.3,92.26 v1(96.66,92.26) ; 97.59,84.9 Q2.6
  IN2 w0.508: v1(96.66,92.26) 95.98,92.94 91.9,92.94 89.59,90.63 83.4,90.63 82.54,91.49 70.78,91.49 67.89,88.59 64.47,88.59 63.94,88.06 59.96,88.06 59.43,87.53 54.1,87.53 47.21,80.64 37.89,80.64 34.83,77.58 34.83,76.05 33.92,75.13 32.47,75.13 28.99,71.65 28.99,70.61 28.29,69.91 28.29,68.95 28.29,68.94 28.29,67.17 27.97,66.85 27.97,64.04 28.61,63.4 29.9,63.4 31.15,62.15 32.95,62.15 33.46,61.64 38.08,61.64 39.43,60.29 40.37,60.29 42.39,58.27 45.55,58.27 46.23,57.58 48.44,57.58 51.21,54.81 51.21,49.45 54.52,46.15 54.52,39.04 v1(53.12,37.64)
  IN3 w0.254: 50.45,28.03 50.45,21.26
  IN3 w0.508: v1(53.12,37.64) 52.72,37.64 52.1,37.02 52.1,34.09 50.71,32.69 50.71,31.51 50.79,31.43 50.79,28.37 50.45,28.03 ; v1(69.5,16.18) 69.5,17.01 69.25,17.27 68.34,17.27 67.47,18.13 61.5,18.13 59.67,19.97 51.74,19.97 50.45,21.26
  BOTTOM w0.305: U22.D27 98.58,73.53 v1(98.74,73.53)
RTC_TEST#: length 202.1
  TOP w0.508: v1(64.29,16.18) 64.29,15.33 65.23,14.4 65.56,14.4 v1(66.01,13.96) 66.72,13.25 C300.1 R357.2 ; v1(91.74,94.32) 92.2,94.32 94.19,92.33 94.19,90.11 93.43,89.34 93.43,87.48 91.98,86.03 91.98,83.69 92.31,83.36 94.24,83.36 94.48,83.6 Q2.3 94.85,83.49 94.85,82.73 94.62,82.5 94.62,79.2 96.12,77.7 96.12,76.53 97.26,75.39 97.26,74.46 97.97,73.74 97.97,73.44 98.51,72.9 v1(98.74,72.9) ; v1(50.2,54.53) 50.2,54.53 R180.1
  IN2 w0.508: v1(91.74,94.32) 91.49,94.32 88.69,91.52 83.77,91.52 82.91,92.38 70.42,92.38 67.52,89.48 64.1,89.48 63.57,88.95 59.6,88.95 59.06,88.42 53.73,88.42 46.84,81.53 37.52,81.53 33.51,77.52 29.37,77.52 27.54,75.69 27.54,70.53 27.4,70.39 27.4,68.58 27.4,68.58 27.4,67.54 27.08,67.22 27.08,62.63 28.77,60.95 29.93,60.95 31.27,59.61 32.79,59.61 33,59.4 40,59.4 42.43,56.97 44.84,56.97 45.52,56.28 48.44,56.28 v1(50.2,54.53) 49.31,53.63 49.31,49.83 49.83,49.31 49.83,47.34 51.75,45.42 51.75,44.46 51.47,44.19 51.47,42.47 51.85,42.09 51.85,39.67 51.47,39.29 v1(51.47,37.64)
  IN3 w0.254: 49.31,28.62 49.05,28.37 49.05,20.88
  IN3 w0.508: v1(64.29,16.18) 63.73,16.74 59.67,16.74 58.89,17.52 50.91,17.52 49.05,19.37 49.05,20.88 ; v1(51.47,37.64) 51.09,37.26 51.09,34.47 49.51,32.89 49.51,28.83 49.31,28.62
  BOTTOM w0.305: v1(98.74,72.9) 99.09,72.54 U22.F25
RTC_X1: length 11.4
  BOTTOM w0.079: 99.47,73.94 99.47,74.09 99.19,74.37 99.04,74.37 98.86,74.55 98.86,74.78 99.07,74.98 99.07,75.23
  BOTTOM w0.089: U22.D23 99.47,73.91 99.47,73.94
  BOTTOM w0.14: 99.07,75.23 99.07,76.6 100.27,77.81 100.27,78.75 100.07,78.95 v1(100.07,79.5) 100.1,79.53 R431.1 100.1,81.19 C361.2 100.16,81.47 100.16,81.93 Y2.1
RTC_X2: length 11.4
  TOP w0.14: v1(100.64,79.17) 100.34,78.87 100.34,78.26 100.38,78.22 100.38,74.09 100.19,73.9 100.19,73.31 100.31,73.19 100.31,73.16 v1(100.57,72.9)
  BOTTOM w0.089: v1(100.57,72.9) 100.13,72.57 U22.F23
  BOTTOM w0.14: Y2.2 101.74,82.05 C362.2 100.99,80.42 R431.2 100.88,79.41 v1(100.64,79.17)
S5_ON: length 308.4
  TOP w0.127: v1(18.01,67.84) 17.56,67.39 17.56,65.22 24.66,58.12 32.87,58.12 34.36,56.63 37.79,56.63 40.38,59.22 46.3,59.22 v1(47.2,60.12) ; v1(44.44,27.13) 44.23,26.91 43.53,26.91 42.83,26.21 42.08,26.21 R312.1 ; v1(48.95,38.97) 48.77,38.97 48.07,39.67 47.25,39.67 47.13,39.8 45.4,39.8 45.21,39.61 44.28,39.61 R276.2 R275.1 R268.1 43.42,42.09 v1(43.16,42.34) ; v1(41.63,62.08) 41.63,62.11 41.05,62.69 PR44.2 ; v1(156.07,14.39) 156.62,13.84 PR100.2
  IN1 w0.089: v1(156.37,66.47) 156.75,66.47 157.49,67.21 158.63,67.21 159.8,66.04 159.8,64.61 161.2,63.2 161.2,59.69 161.53,59.36 161.53,50.19 161.2,49.86 161.2,49.07 160.79,48.65 160.79,46.61 159.11,44.94 159.11,44.83 157.87,43.59 157.87,41.01 159.69,39.2 159.69,31.48 159.1,30.89 158.17,30.89 157.78,31.28 151.35,31.28 148.5,28.43 148.5,26.61 150.23,24.88 150.23,18.79 150.69,18.34 151.29,18.34 151.93,17.7 151.93,16.82 152.73,16.01 154.45,16.01 v1(156.07,14.39)
  IN3 w0.127: v1(48.95,38.97) 48.73,38.97 46.39,36.63 46.39,34.3 44.81,32.73 44.81,27.49 v1(44.44,27.13) 43.74,26.42 43.74,22.91 44.85,21.8 44.85,20.64 45.99,19.5 45.99,16.41 49.46,12.94 53.55,12.94 55.64,10.84 58.93,10.84 59.28,10.49 74.42,10.49 76.31,12.38 87.55,12.38 89.02,10.91 111.01,10.91 111.77,11.67 120.02,11.67 121.91,13.56 121.91,17.56 124.41,20.06 125.92,20.06 126.43,20.57 136.62,20.57 137.62,21.58 139.71,21.58 140.07,21.94 141.54,21.94 143.18,20.31 147.56,20.31 148.07,19.8 150.87,19.8 151.91,18.76 151.91,18.55 v1(156.07,14.39)
  BOTTOM w0.127: PR173.2 v1(18.01,67.84) ; PR174.1 157,67.35 156.37,66.72 v1(156.37,66.47) ; v1(43.16,42.34) 44.29,43.47 44.29,45.58 45.02,46.3 47.3,46.3 47.53,46.53 50.08,46.53 50.64,47.09 50.64,51.04 49.69,51.99 49.69,56.93 48,58.62 48,59.16 47.2,59.96 v1(47.2,60.12) 47.2,60.4 45.92,61.68 42.03,61.68 v1(41.63,62.08)
S5_ON_R: length 2.7
  TOP w0.127: R312.2 v1(39.78,26.85)
  TOP w0.14: v1(39.78,26.85) 39.78,26.97 39.18,27.58 U14.69
SATA_DEVSLP0: length 3.1
  TOP w0.127: Q16.6 55.4,15.17 55.15,15.42 R343.1 54.77,16.31 v1(55.02,16.56)
  BOTTOM w0.127: v1(55.02,16.56) 55.4,16.18 R605.2
SATA_DEVSLP0_R: length 11.1
  BOTTOM w0.127: CN15.9 52.85,12.46 53.39,13 54.39,13 55.15,13.77 v1(55.15,14.15) 55.4,14.4 R605.1
SATA_DEVSLP1: length 20
  TOP w0.127: Q15.6 51.45,15.76 51.04,16.18 v1(50.2,16.18) 51.09,17.07 53.55,17.07 53.61,17 53.62,17 53.88,16.74 53.88,16.18 53.75,16.05 R342.1
  BOTTOM w0.127: R604.2 43.07,10.32 44.86,12.11 46.39,12.11 46.9,11.61 47.82,11.61 49.96,13.74 49.96,15.94 v1(50.2,16.18)
SATA_GP0: length 1.3
  TOP w0.127: v1(93.47,72.19) 93.47,72.86 TP6.1
  BOTTOM w0.089: U22.H37 v1(93.47,72.19)
SATA_RXN0: length 78.8
  TOP w0.14: v1(108.24,70.78) 108.42,70.6 109.95,70.6 111.3,69.24 114.23,69.24 114.9,69.92 114.9,70.33 115.75,71.19 119.27,71.19 119.27,71.19 119.36,71.19 119.44,71.19 119.49,71.19 119.5,71.18 120.07,70.6 120.19,70.49 120.19,69.5 123.32,66.36 123.32,60.64 117.32,54.63 117.32,47.36 118.86,45.82 118.86,36.16 122.91,32.12 122.91,29.8 126.38,26.33 131.82,26.33 134.91,23.24 135.84,23.24 135.92,23.32 v1(135.92,23.54)
  BOTTOM w0.089: U22.J5 107.88,70.97 108.06,70.78 v1(108.24,70.78)
  BOTTOM w0.14: v1(135.92,23.54) 135.92,23.34 135.8,23.22 135.26,23.22 135.17,23.31 C458.2
SATA_RXN0_CN: length 88.8
  IN1 w0.089: v1(124.39,24.32) 124.39,24.05 124.31,23.98 123.35,23.98 121.62,25.7 119.21,25.7 115.86,22.35 115.86,21.72 115.51,21.37 113.42,21.37 111.36,19.31 98.84,19.31 97.85,18.32 90.04,18.32 86.08,14.36 76.24,14.36 75.13,13.24 60.99,13.24 60.34,13.88 60.34,14.42 60.55,14.63 60.89,14.63 60.96,14.56 v1(60.96,14.28)
  BOTTOM w0.14: v1(60.96,14.28) 60.96,14.5 60.86,14.6 58.66,14.6 56.8,12.75 55.86,12.75 54.72,11.61 54.72,6.57 54.85,6.43 CN15.5 ; C459.1 125.73,23.23 125.53,23.04 125.3,23.04 125.13,23.21 125.13,23.7 124.82,24 124.49,24 124.39,24.1 v1(124.39,24.32)
SATA_RXN0_HDD#_IC: length 2.8
  BOTTOM w0.14: U32.4 132.53,23.68 132.64,23.56 132.98,23.56 133.25,23.3 134.01,23.3 C458.1
SATA_RXN_1ST_HDD#_C_RD: length 2.1
  BOTTOM w0.14: U32.12 127.6,23.68 127.46,23.54 127.28,23.54 126.85,23.11 126.6,23.11 126.51,23.2 C459.2
SATA_RXP0: length 78.9
  TOP w0.14: v1(107.53,70.78) 107.98,70.33 109.84,70.33 111.19,68.98 114.34,68.98 115.16,69.8 115.16,70.22 115.87,70.92 119.38,70.92 119.88,70.42 119.92,70.38 119.92,69.39 123.06,66.25 123.06,60.75 117.05,54.74 117.05,47.25 118.59,45.71 118.59,36.05 122.64,32.01 122.64,29.69 126.27,26.06 131.71,26.06 134.8,22.97 135.73,22.97 v1(135.92,22.78)
  BOTTOM w0.089: U22.J7 107.17,71.14 v1(107.53,70.78)
  BOTTOM w0.14: C460.2 135.46,22.95 135.76,22.95 v1(135.92,22.78)
SATA_RXP0_CN: length 88.8
  IN1 w0.089: v1(60.96,15.04) 60.74,14.82 60.47,14.82 60.15,14.5 60.15,13.81 60.91,13.05 75.2,13.05 76.32,14.17 86.16,14.17 90.12,18.13 97.93,18.13 98.92,19.12 111.44,19.12 113.5,21.18 115.59,21.18 116.05,21.64 116.05,22.27 119.29,25.51 121.54,25.51 123.27,23.79 124.17,23.79 124.39,23.57 v1(124.39,23.56)
  BOTTOM w0.14: v1(60.96,15.04) 60.79,14.87 58.54,14.87 56.69,13.02 55.75,13.02 54.45,11.72 54.45,6.57 54.35,6.46 CN15.6 ; C461.1 125.44,22.77 125.19,22.77 124.86,23.1 124.86,23.59 124.71,23.73 124.58,23.73 124.39,23.55 v1(124.39,23.56)
SATA_RXP0_HDD_IC: length 2.8
  BOTTOM w0.14: C460.1 134.01,23.03 133.14,23.03 132.87,23.3 132.64,23.3 132.53,23.18 U32.5
SATA_RXP_1ST_HDD_C_RD: length 2.1
  BOTTOM w0.14: C461.2 126.51,22.79 126.56,22.85 126.96,22.85 127.39,23.27 127.51,23.27 127.6,23.18 U32.11
SATA_TXN0: length 80.6
  TOP w0.14: v1(135.92,24.81) 136.16,25.06 136.47,25.06 136.76,25.35 136.76,26.39 135.91,27.24 126.76,27.24 123.82,30.18 123.82,32.5 119.77,36.54 119.77,46.2 118.23,47.74 118.23,54.25 124.24,60.26 124.24,66.74 121.1,69.88 121.1,70.87 119.87,72.11 111.79,72.11 111.13,72.77 111.13,74.07 v1(111.32,74.26)
  BOTTOM w0.089: U22.J2 109.38,71.41 109.47,71.41 110.09,72.04 110.09,72.64 111.07,73.62 111.07,74.01 v1(111.32,74.26)
  BOTTOM w0.14: v1(135.92,24.81) 135.67,25.06 135.54,25.06 C455.2
SATA_TXN0_CN: length 89.2
  IN1 w0.089: v1(124.52,26.32) 124.77,26.07 124.77,25.96 124.64,25.83 123.54,25.83 121.46,27.91 120.15,27.91 115.39,23.14 113.25,23.14 112.88,22.77 112.88,21.76 111.09,19.97 98.57,19.97 97.91,19.31 87.16,19.31 86.82,18.96 86.82,16.03 85.81,15.02 75.97,15.02 74.85,13.9 65.65,13.9 64.15,15.4 63.75,15.4 v1(63.47,15.68)
  BOTTOM w0.14: CN15.3 55.85,6.69 55.98,6.81 55.98,10.51 58.27,12.8 61.4,12.8 62.38,13.78 62.38,15.11 62.71,15.44 63.22,15.44 v1(63.47,15.68) ; v1(124.52,26.32) 124.7,26.15 124.7,25.4 125.29,24.8 125.48,24.8 C456.1
SATA_TXN0_HDD#_IC: length 2.8
  BOTTOM w0.14: U32.2 132.53,24.68 132.64,24.8 133.12,24.8 133.38,25.06 134.01,25.06 C455.1
SATA_TXN_1ST_HDD#_C_RD: length 2
  BOTTOM w0.14: U32.14 127.5,24.68 127.38,24.8 127.02,24.8 126.89,24.93 126.59,24.93 126.51,24.85 C456.2
SATA_TXP0: length 80.5
  TOP w0.14: v1(110.68,74.26) 110.87,74.07 110.87,72.66 111.68,71.84 119.76,71.84 120.83,70.76 120.83,69.77 123.97,66.63 123.97,60.37 117.96,54.36 117.96,47.63 119.51,46.09 119.51,36.43 123.55,32.39 123.55,30.07 126.65,26.97 135.8,26.97 136.49,26.28 136.49,25.46 136.36,25.32 136.18,25.32 v1(135.92,25.58)
  BOTTOM w0.089: U22.J3 108.8,71.32 109.2,71.59 109.4,71.59 109.91,72.11 109.91,72.72 110.89,73.7 110.89,74.05 v1(110.68,74.26)
  BOTTOM w0.14: v1(135.92,25.58) 135.67,25.33 135.54,25.33 C451.2
SATA_TXP0_CN: length 89.2
  IN1 w0.089: v1(125.29,26.32) 124.96,26 124.96,25.88 124.72,25.64 123.46,25.64 121.38,27.72 120.23,27.72 115.47,22.95 113.33,22.95 113.07,22.69 113.07,21.68 111.17,19.78 98.65,19.78 97.99,19.12 87.24,19.12 87.01,18.88 87.01,15.95 85.88,14.83 76.05,14.83 74.93,13.71 65.57,13.71 64.08,15.21 63.75,15.21 v1(63.47,14.92)
  BOTTOM w0.14: CN15.2 56.35,6.68 56.24,6.79 56.24,10.4 58.38,12.53 61.51,12.53 62.65,13.67 62.65,14.99 62.82,15.17 63.22,15.17 v1(63.47,14.92) ; C453.1 125.73,25.16 125.64,25.07 125.4,25.07 124.96,25.51 124.96,26.19 125.09,26.32 v1(125.29,26.32)
SATA_TXP0_HDD_IC: length 2.8
  BOTTOM w0.14: U32.1 132.53,25.18 132.64,25.06 133.01,25.06 133.27,25.33 134.01,25.33 C451.1
SATA_TXP_1ST_HDD_C_RD: length 2
  BOTTOM w0.14: U32.15 127.5,25.18 127.38,25.06 127.14,25.06 127,25.2 126.59,25.2 126.51,25.29 C453.2
SD_CD#: length 10.3
  TOP w0.14: v1(167.93,41.96) 167.91,41.98 U11.13
  BOTTOM w0.14: v1(167.93,41.96) 168.43,41.46 v1(168.43,39.55) R552.1
SD_CD#_R: length 2.8
  BOTTOM w0.14: R552.2 169.69,32.33 v1(170.09,32.33) CN11.1
SD_CLK: length 30.5
  TOP w0.14: U11.15 167.92,42.98 v1(167.93,42.98)
  IN3 w0.127: v1(167.93,42.98) 168.45,42.45 168.45,35.7 170.01,34.14 170.01,26.36 170.91,25.45 170.91,25.14 170.78,25.01 170.57,25.01 170.44,24.88 170.44,24.63 170.57,24.5 170.78,24.5 170.91,24.37 170.91,24.12 170.78,23.99 170.57,23.99 170.44,23.87 170.44,23.61 170.57,23.49 170.78,23.49 170.91,23.36 170.91,19.06 169.83,17.98 v1(169.83,17.91)
  BOTTOM w0.14: R593.1 169.83,17.31 v1(169.83,17.91)
SD_CLK_R: length 5.2
  BOTTOM w0.14: R593.2 168.43,16.86 169.2,17.64 R586.1 C467.1 169.88,18.72 v1(170.09,18.51) 170.27,18.33 CN11.7
SD_CMD: length 31.9
  TOP w0.14: v1(167.93,47.42) 167.42,46.91 167.42,44.92 U11.18
  IN3 w0.127: v1(167.8,26.71) 168.56,27.47 168.56,29.28 168.69,29.41 169.25,29.41 169.35,29.51 169.35,29.82 169.25,29.92 168.69,29.92 168.56,30.05 168.56,30.3 168.69,30.43 169.26,30.43 169.36,30.53 169.36,30.83 169.26,30.93 168.69,30.93 168.56,31.06 168.56,31.32 168.69,31.44 169.22,31.44 169.35,31.57 169.35,31.82 169.22,31.95 168.69,31.95 168.56,32.08 168.56,32.33 168.69,32.46 169.22,32.46 169.35,32.59 169.35,32.84 169.22,32.97 168.69,32.97 168.56,33.09 168.56,33.58 167.46,34.68 167.46,39.85 166.66,40.65 166.66,43.24 168.41,45 168.41,46.94 v1(167.93,47.42)
  BOTTOM w0.14: v1(167.8,26.71) 168.42,26.71 R571.1
SD_CMD_R: length 3.7
  BOTTOM w0.14: CN11.4 170.21,25.82 v1(170.09,25.7) C452.1 R571.2
SD_D0: length 31.7
  TOP w0.14: U11.11 165.63,40.69 166.62,39.69 166.62,38.9 165.87,38.15 v1(165.77,38.15)
  IN3 w0.127: v1(165.77,38.15) 165.68,38.15 165.32,37.79 165.32,31.9 166.85,30.37 166.85,26.94 167.59,26.2 167.93,26.2 168.27,25.86 168.45,25.86 168.84,26.25 168.99,26.25 169.2,26.03 169.2,25.89 168.81,25.5 168.81,25.32 169.26,24.87 169.26,18.75 168.37,17.86 168.37,16.85 167.8,16.28 v1(167.8,15.04)
  BOTTOM w0.14: v1(167.8,15.04) 168.18,15.42 R608.1
SD_D1: length 31.8
  TOP w0.14: U11.10 165.13,40.52 166.1,39.54 166.1,39.12 v1(165.77,38.78)
  IN3 w0.127: v1(165.77,38.78) 165.6,38.78 164.81,38 164.81,31.68 166.34,30.16 166.34,26.73 167.35,25.72 167.35,23.61 167.61,23.35 167.94,23.35 168.75,22.54 168.75,18.96 167.86,18.07 167.86,17.07 167.29,16.49 167.29,14.27 v1(167.8,13.77)
  BOTTOM w0.14: R614.1 168.04,13.77 v1(167.8,13.77)
SD_D2: length 31.8
  TOP w0.14: U11.21 165.13,46.97 165.84,47.68 v1(165.84,47.98)
  IN3 w0.127: v1(167.93,32.31) 166.95,33.28 166.95,39.63 166.15,40.44 166.15,41.08 166.02,41.2 165.23,41.2 165.1,41.33 165.1,41.58 165.23,41.71 166.02,41.71 166.15,41.84 166.15,44.11 166.28,44.25 166.94,44.25 167.04,44.35 167.04,44.65 166.94,44.75 166.47,44.75 166.37,44.85 166.37,45.16 166.47,45.26 167.8,45.26 167.9,45.36 167.9,45.67 167.8,45.77 166.5,45.77 166.4,45.87 166.4,46.18 166.5,46.28 167.38,46.28 167.48,46.38 167.48,46.68 167.38,46.79 166.71,46.79 166.46,47.04 166.46,47.23 167.86,48.64 167.86,48.78 167.65,49 167.5,49 166.25,47.75 166.07,47.75 v1(165.84,47.98)
  BOTTOM w0.14: v1(167.93,32.31) 168.43,31.81 R553.1
SD_D3: length 31.7
  TOP w0.14: U11.20 165.63,46.38 v1(165.89,46.64)
  IN3 w0.127: v1(167.8,27.48) 167.67,27.48 167.35,27.8 167.35,32.16 166.44,33.07 166.44,39.27 165.42,40.29 165.24,40.29 164.35,39.4 164.21,39.4 163.99,39.62 163.99,39.76 164.88,40.65 164.88,40.83 164.7,41.01 164.52,41.01 163.78,40.26 163.63,40.26 163.42,40.48 163.42,40.62 164.16,41.37 164.16,41.55 163.56,42.15 163.56,44.31 164.14,44.89 164.32,44.89 164.7,44.51 164.88,44.51 165.06,44.69 165.06,44.86 164.68,45.25 164.68,45.42 164.86,45.6 165.03,45.6 165.42,45.22 165.59,45.22 165.77,45.4 165.77,45.58 165.39,45.96 165.39,46.14 v1(165.89,46.64)
  BOTTOM w0.14: R570.1 168.17,27.48 v1(167.8,27.48)
SD_D4: length 3.6
  TOP w0.127: U11.19 166.13,45.88 166.53,46.28 166.53,48.06 TP20.1
SD_D5: length 1.8
  TOP w0.127: TP22.1 168.43,43.48 U11.16
SD_D6: length 1.8
  TOP w0.127: U11.14 168.42,42.48 TP23.1
SD_D7: length 2.5
  TOP w0.127: TP28.1 167.27,39.57 166.13,40.71 U11.12
SD_DATA0_R: length 3.9
  BOTTOM w0.14: R608.2 C481.1 v1(170.09,14.4) 170.58,13.9 CN11.9
SD_DATA1_R: length 3.9
  BOTTOM w0.14: CN11.10 171.01,12.2 170.62,12.6 v1(170.03,12.6) 169.88,12.6 169.65,12.37 C483.1 R614.2
SD_DATA2_R: length 3.7
  BOTTOM w0.14: CN11.2 170.13,30.82 v1(170.09,30.78) C438.1 R553.2
SD_DATA3_R: length 3.8
  BOTTOM w0.14: R570.2 C448.1 169.7,28.75 v1(170.09,28.37) 170.13,28.33 CN11.3
SD_WP: length 33.5
  TOP w0.14: U11.8 164.13,40.32 164.45,40 164.45,39.63 164.7,39.37 165.53,39.37 v1(165.57,39.42)
  IN3 w0.127: v1(165.57,39.42) 165.51,39.42 164.05,37.96 164.05,31.6 165.83,29.82 165.83,26.25 166.85,25.24 166.85,23.4 167.4,22.85 167.73,22.85 168.24,22.33 168.24,19.17 167.35,18.28 167.35,17.28 166.78,16.7 166.78,13.56 v1(167.16,13.18)
  BOTTOM w0.14: R618.1 166.65,12.66 v1(167.16,13.18)
SD_WP_R: length 5.2
  BOTTOM w0.14: R618.2 167.95,11.85 169.71,11.85 171.06,10.5 CN11.11
SDREG: length 2.4
  TOP w0.102: 162.87,40.51 v1(162.82,40.56)
  TOP w0.305: C225.2 162.97,40.41 162.87,40.51 ; v1(162.82,40.56) 162.82,41.58 162.78,41.62 U11.6
SENSEA: length 4.3
  TOP w0.203: v1(183.04,15.01) 182.79,15.26 182.79,15.42 182.58,15.62 U16.13
  TOP w0.254: v1(183.04,15.01) 183.14,14.91 184.69,14.91 184.95,15.17 R340.1 R341.2
SET1_VCGI: length 5.5
  TOP w0.127: PR45.1 50.91,63.42 v1(51.39,63.9)
  BOTTOM w0.127: PR45.1 50.57,63.79 51.27,63.79 v1(51.39,63.9) 52.56,65.07 52.98,65.07 53.11,64.95 PU10.28
SET1_VNN: length 4.7
  TOP w0.203: PR57.2 36.55,62.34 v1(36.46,62.34) 35.83,62.96 35.19,62.96 34.98,63.17 PU1.28
  BOTTOM w0.127: v1(36.86,62.91) 36.86,62.75 v1(36.46,62.34)
  BOTTOM w0.203: PR212.1 36.1,61.99 v1(36.46,62.34)
SET2_VCGI: length 6.5
  TOP w0.127: v1(52.61,64.29) 52.61,64.28 50.74,62.41 PR48.1
  BOTTOM w0.127: PR199.2 51.98,63.66 v1(52.61,64.29) 52.61,64.1 52.93,63.78 53.37,63.78 53.51,63.92 PU10.27
SET2_VNN: length 3.8
  TOP w0.203: 35.52,62.47 35,62.47 34.58,62.89 PU1.27 ; 35.52,62.47 v1(35.54,62.47) ; 35.52,62.47 36.1,61.89 PR56.2
  BOTTOM w0.203: PR211.1 34.96,61.75 35.54,62.34 v1(35.54,62.47)
SET3_VCGI: length 5
  TOP w0.127: PR50.1 51.73,62.16 v1(52.23,62.66) 52.53,62.96 v1(52.53,63.55)
  BOTTOM w0.127: v1(52.53,63.55) 52.56,63.52 53.28,63.52 PR200.2 53.91,63.19 PU10.26
SET3_VNN: length 3.1
  TOP w0.203: PR55.2 34.96,61.78 34.27,62.47 v1(34.26,62.47) 34.18,62.55 PU1.26
  BOTTOM w0.203: v1(34.26,62.47) 33.81,62.02 PR210.1
SIO_EXT_SCI#: length 83.2
  TOP w0.127: U14.23 23.58,29.58 23.71,29.72 26.09,29.72 27.44,28.37 v1(27.97,28.37)
  IN3 w0.127: v1(27.97,28.37) 29.09,28.37 29.7,27.76 33.03,27.76 41.1,35.83 41.1,36.9 41.63,37.43 45.57,37.43 47.07,38.93 47.07,39.6 47.66,40.18 47.66,41.32 48.85,42.52 v1(48.85,45.64)
  BOTTOM w0.089: R497.2 R496.2
  BOTTOM w0.14: R496.2 78.61,64.27 77.88,64.27 77.85,64.3 R495.1 77.25,64.1 76.61,63.47 71.18,63.47 70.93,63.22 69.83,63.22 69.37,63.68 66.33,63.68 64.08,61.43 63.11,61.43 61.04,59.36 61.04,57.53 60.66,57.15 58.83,57.15 58.55,56.87 58.55,54.3 57.11,52.86 57.11,47.83 55.35,46.07 50.62,46.07 50.19,45.64 v1(48.85,45.64)
SIO_RCIN#: length 2.2
  TOP w0.14: U14.4 21.92,37.18 21.45,37.64 TP32.1
SLEEVE: length 0.9
  TOP w0.203: 183.46,17.79 U16.18
  vias: v1(172.27,38.38) v1(172.38,37.68) v1(172.84,37.22) v1(184.56,18.08) v1(185.45,18.08)
SLEEVE_R: length 18.6
  TOP w1.016: 171.43,39.42 173.01,39.42 175.22,37.21 178.24,37.21 180.12,35.33 183.24,35.33 185,37.09 185,39.65 CN8.4
  vias: v1(170.29,39.14)
SMB1ALERT#: length 191.9
  IN1 w0.089: v1(107.41,88.34) 107.06,87.99 105.3,87.99 105.05,88.24 104.99,88.3 103.89,89.41 98.81,89.41 97.29,90.93 95.28,90.93 94.02,92.19 90.93,92.19 90.56,91.82 84.06,91.82 83.16,92.71 68.61,92.71 63.27,87.37 58.3,87.37 57.85,86.92 57.85,85.27 57.33,84.76 54.63,84.76 48.48,78.6 23.23,78.6 21.43,76.81 21.43,70.86 21.81,70.49 21.81,54.9 19.84,52.94 19.84,49.68 20.91,48.61 20.91,46.48 23.84,43.55 25.05,43.55 26.45,42.15 26.45,41.1 27.98,39.57 28.42,39.57 29.01,38.98 29.01,37.72 v1(29.39,37.34)
  BOTTOM w0.089: U22.A26 98.71,75 98.71,77.27 99.03,77.59 R444.1 99.03,79.41 99.27,79.64 99.27,80.26 98.68,80.85 98.68,81.54 98.6,81.63 98.6,82.15 98.24,82.51 98.24,83.49
  BOTTOM w0.127: 98.24,83.49 98.24,84.16 98.96,84.88 R405.1 99.74,85.39 104.05,85.39 104.43,85.77 v1(105.7,85.77) 106.52,85.77 107.41,86.66 v1(107.41,88.34) ; Q35.5 16.75,20.47 17.1,20.83 17.1,21.29 17.3,21.49 18.02,21.49 18.48,21.95 18.88,21.95 20.09,23.16 22.36,23.16 24.06,24.86 27.21,24.86 28.37,26.03 28.37,28.03 28.42,28.08 28.42,28.69 28.24,28.87 27.61,28.87 27.28,29.2 26.42,30.05 26.42,34.32 27.86,35.76 27.86,36.52 28.68,37.34 v1(29.39,37.34)
SMB_SOC_CLK: length 21.7
  BOTTOM w0.089: 97.84,83.49 97.84,82.66 98.42,82.08 98.42,81.55 98.5,81.47 98.5,80.84 98.44,80.78 98.44,79.74 98.83,79.36 98.83,79.06 98.83,78.73 98.73,78.63 98.45,78.35 98.45,77.39 98.25,77.19 98.25,74.67 U22.B27
  BOTTOM w0.14: Q29.6 102.2,89.44 102.74,88.91 103.06,88.91 R399.1 R398.1 R403.1 102.53,86.8 102.27,86.54 v1(100.49,86.54) 99.22,86.54 98.28,85.6 98.28,85.06 97.84,84.62 97.84,83.49
SMB_SOC_DAT: length 20.9
  BOTTOM w0.089: U22.C27 98.23,74.27 97.97,74.52 97.97,74.81 98.07,74.9 98.07,77.26 98.27,77.46 98.27,78.42 98.65,78.8 98.65,79.14 98.65,79.28 98.27,79.67 98.27,80.85 98.33,80.91 98.33,81.39 98.24,81.48 98.24,81.95 97.44,82.75 97.44,83.49
  BOTTOM w0.14: Q29.3 100.68,90.74 100.79,90.63 100.79,89.26 100.58,89.05 98.58,89.05 98.45,88.91 R397.1 R402.1 98.45,86.53 v1(98.08,86.16) 97.89,85.96 97.89,85.23 97.44,84.78 97.44,83.49
SOC_OVRIDE: length 20.5
  BOTTOM w0.089: 83.64,67.85 83.64,67.89 84.01,68.27 85.86,68.27 U22.T55
  BOTTOM w0.14: Q33.3 70.39,64.69 v1(70.77,64.31) 71.35,63.73 76.37,63.73 76.7,64.06 76.7,66.21 77.29,66.81 80.64,66.81 R483.2 81.45,66.85 82.2,66.85 82.56,67.21 82.99,67.21 83.64,67.85
SOC_PCI_SERR#: length 1.8
  BOTTOM w0.089: R486.2 v1(79.41,66.09) R485.2
SOC_PWRBTN#: length 5.9
  TOP w0.127: C84.2 81.81,74.08 81.92,74.19 81.92,74.89 v1(82.17,75.14) 82.98,75.95 v1(82.98,77.45)
  BOTTOM w0.127: R446.2 82.53,77.9 v1(82.98,77.45)
SOC_RSMRST#: length 98.4
  TOP w0.14: R132.2 80.64,64.57 C119.2 80.81,65.48 v1(80.55,65.48) ; v1(52.89,43.08) 52.89,44.71 51.11,46.49 46.91,46.49 45.99,47.41 40.67,47.41 v1(40.29,47.04) 39.95,46.7 39.74,46.7 39.11,46.07 38.08,46.07 36.66,44.64 35.94,44.64 35.63,44.96 34.62,44.96 34.43,44.77 30.29,44.77 30.01,44.5 R249.2 29.23,43.08 R263.2
  IN1 w0.089: v1(52.89,43.08) 53.22,43.08 60.48,50.34 60.48,51.77 62.01,53.3 62.01,55.19 65.34,58.52 65.99,58.52 68.12,60.65 72.57,60.65 73.71,61.79 75.11,61.79 75.58,62.26 77.23,62.26 80.43,65.45 80.52,65.45 v1(80.55,65.48) 80.55,66.2 81.65,67.29 83.01,67.29 84.18,68.46 86.29,68.46 86.31,68.48 91.16,68.48 91.48,68.16 92.84,68.16 94.19,69.51 94.19,73.28 95.03,74.11 97.24,74.11 97.72,73.63 97.72,72.54 v1(98.79,71.47)
  BOTTOM w0.089: v1(98.79,71.47) 98.76,71.45 98.23,71.45 97.97,71.7 97.97,71.96 98.1,72.08 98.1,72.34 U22.F27
SOC_SERIRQ: length 120.6
  TOP w0.14: v1(43.22,55.71) 43.22,55.02 38.88,50.68 37.31,50.68 34.36,47.74 33.52,47.74 33.07,47.29 27.72,47.29 25.04,49.97 22.9,49.97 v1(22.38,49.45) 21.75,48.82 21.74,48.82 R207.2 21.38,48.45 R216.1 22.4,46.4 U10.4
  IN1 w0.089: v1(43.22,55.71) 42.62,56.32 42.62,61.24 43.14,61.77 43.14,63.07 44.38,64.3 49.17,64.3 50.32,63.15 52.69,63.15 54.6,65.06 55.65,65.06 59.58,68.99 63.23,68.99 63.88,69.65 64.52,69.65 67.21,72.34 67.21,78.56 65.6,80.16 65.6,84.91 64.86,85.65 64.86,85.98 68.52,89.65 81.65,89.65 86.24,85.06 90.16,85.06 92.27,82.95 92.96,82.95 v1(93.88,82.03)
  BOTTOM w0.089: v1(93.88,82.03) 93.88,81.58 R422.1
  BOTTOM w0.14: U23.3 42.74,57.69 42.05,57 42.05,56.85 41.84,56.64 R524.1 R525.1 42.84,56.09 v1(43.22,55.71)
SOC_SERIRQ_R: length 6.6
  BOTTOM w0.089: U22.B37 93.77,74.71 93.77,75.28 93.43,75.62 93.43,76.18 94.01,76.76 94.01,78.33 v1(94.32,78.64) 94.01,78.94 94.01,79.67 R422.2
SP14: length 3
  TOP w0.127: TP19.1 164.63,48.18 U11.22
SPI_CLK_A: length 3
  BOTTOM w0.14: R394.2 91.93,89.08 91.88,89.13 TP46.1 90.86,89.13 90.43,88.7 U21.6
SPI_CS0#_UR_ME: length 18.4
  TOP w0.14: U14.101 35.11,38.82 v1(34.82,38.53)
  IN1 w0.089: v1(34.82,38.53) 34.82,41.56 36.61,43.35 36.61,46.53 v1(38.24,48.16)
  BOTTOM w0.14: v1(38.24,48.16) 38.24,48.04 R538.2 36.9,47.62 TP57.1 35.54,47.62 35.01,47.09 U29.1
SPI_HOLD#: length 2.6
  BOTTOM w0.14: U29.7 26.77,45.82 26.45,46.14 v1(26.32,46.14) R541.2
SPI_WP#: length 4.7
  BOTTOM w0.14: R547.2 36.98,42.86 35.29,44.55 v1(34.96,44.55) U29.3
SPIVCC_ON: length 4.5
  TOP w0.127: R259.1 36.74,42.6 36.48,42.34 36.11,42.34 35.84,42.07 R271.2 35.08,41.71 v1(34.83,41.45) 34.88,41.45 35.51,40.82 U14.100
SPKR: length 179.9
  TOP w0.14: v1(145.16,31.69) 145.16,31.64 145.16,31.64 145.16,30.33 v1(144.41,29.58) 144.05,29.22 144.05,28.2 143.8,27.95 D31.2
  IN1 w0.089: v1(145.16,31.69) 145.16,31.61 144.46,30.9 132.07,30.9 131.71,30.54 117.8,30.54 117.09,29.83 117.09,27.09 115.68,25.67 113.74,25.67 111.94,23.87 111.94,22.15 111.1,21.31 110.7,20.91 104.27,20.91 103.01,22.17 102.25,22.17 101.19,21.1 98.1,21.1 97.44,20.44 84.52,20.44 84.17,20.78 49.31,20.78 48.71,21.38 48.71,25.03 48.37,25.37 48.37,29.85 55.85,37.32 55.85,40.94 64.32,49.41 64.32,50.87 65.06,51.61 66.07,51.61 66.33,51.87 66.33,52.52 67.16,53.36 v1(67.16,53.52)
  IN3 w0.127: v1(84.68,65.58) 84.14,65.04 79.15,65.04 78.65,65.54 72.13,65.54 71.15,64.57 71.15,63.55 70.29,62.68 70.29,61.24 69.65,60.6 69.65,60 69.25,59.59 69.25,57.17 68.43,56.36 68.43,55.29 67.98,54.84 67.98,54.33 v1(67.16,53.52)
  BOTTOM w0.079: v1(84.68,65.58) 84.86,65.76
  BOTTOM w0.089: U22.AA54 85.76,65.91 85.6,66.06 85.16,66.06 84.86,65.76
SUSB#: length 94.3
  TOP w0.14: v1(55.15,47.67) 54.29,47.67 51.37,50.6 49.59,50.6 48.1,49.1 v1(47.02,49.1) 44.49,49.1 v1(44.13,48.74) 44.06,48.67 37.99,48.67 37.4,48.09 37.4,47.96 36.51,47.06 35.63,47.06 34.93,46.36 34.08,46.36 33.64,45.92 26.21,45.92 R236.2
  IN1 w0.089: v1(87.09,73.88) 86.84,73.64 85.81,72.61 84.23,72.61 83.17,71.55 83.17,71 81.96,69.8 81.69,69.8 79.87,67.97 79.23,67.97 77.52,66.27 77.52,65.87 76.58,64.93 70.6,64.93 69.96,64.29 67.8,64.29 65.17,61.66 63.81,61.66 59.25,57.1 59.25,55.18 57.63,53.56 57.63,50.16 v1(55.15,47.67)
  IN3 w0.127: v1(46.28,60.16) 46.28,60.01 45.09,58.83 45.09,57.02 45.24,56.87 45.24,55.07 44.89,54.71 44.89,49.5 v1(44.13,48.74)
  BOTTOM w0.089: v1(87.09,73.88) 87.66,73.88 U22.D51
  BOTTOM w0.14: R513.1 45.04,59.67 45.8,59.67 v1(46.28,60.16)
SUSB#_R: length 5.4
  TOP w0.127: R236.1 26.84,42.95 26.84,42.45 v1(27.08,42.21) 27.46,41.83 27.46,41.32 27.59,41.2
  TOP w0.14: U14.119 27.91,40.88 27.59,41.2
SUSC#: length 136.5
  TOP w0.14: v1(20.35,55.17) 18.8,56.72 18.15,56.72 17.07,55.64 17.07,37.91 v1(16.29,37.13) 15.73,36.57 15.73,31.34 16.03,31.04 16.42,31.04 17.05,30.4 17.05,29.89 17.23,29.72 18.09,29.72 19.41,31.04 R296.1
  IN1 w0.089: v1(88.75,71.68) 88.44,71.37 86.32,71.37 85.44,70.49 83.78,70.49 83.67,70.38 83.03,70.38 82.1,69.45 81.83,69.45 80.01,67.63 79.37,67.63 77.86,66.13 77.86,65.73 76.72,64.58 71.62,64.58 71.39,64.35 71.39,63.91 70.63,63.16 69.86,63.16 69.74,63.28 67.28,63.28 65.32,61.31 63.95,61.31 61.02,58.38 61.02,56.46 58.81,54.25 58.81,50.6 54.15,45.95 50.37,45.95 49.44,45.01 48.37,45.01 v1(47.89,45.49)
  IN3 w0.127: v1(47.89,45.49) 47.53,45.84 47.53,48.73 49.05,50.26 49.05,50.72 48.36,51.42 48.36,52.41 48.1,52.67 47.74,52.67 47.02,53.39 47.02,55.85 v1(45.68,57.2)
  BOTTOM w0.089: v1(88.75,71.68) 88.39,71.32 88.39,71.32 U22.J49
  BOTTOM w0.14: v1(45.68,57.2) 45.03,57.84 R521.1 44.54,58.29 44.54,59.88 44.92,60.26 44.92,60.66 44.62,60.95 42.02,60.95 41.79,60.72 39.49,60.72 38.13,59.36 35.55,59.36 34.44,58.25 28.59,58.25 25.63,55.29 20.48,55.29 v1(20.35,55.17)
SUSLED#: length 106.1
  TOP w0.127: v1(24.54,28.37) 23.75,27.58 U14.28 ; v1(70.14,85.39) 69.88,85.65 v1(69.88,86.92) 69.88,87.81 67.73,89.96 R13.1 R14.1
  IN1 w0.089: v1(70.14,85.39) 70.14,85.01 70.42,84.73 70.42,80.36 68.39,78.33 68.39,71.76 64.72,68.1 64.11,68.1 63.13,67.12 60.14,67.12 57.88,64.86 57.05,64.86 56.11,63.93 55.07,63.93 53.16,62.02 50.97,62.02 48.48,59.53 46.04,59.53 45.37,60.2 v1(45.37,60.27)
  IN3 w0.127: v1(45.37,60.27) 43.95,58.85 33.11,58.85 32.92,58.66 28.89,58.66 24.8,54.56 24.8,47.93 22.51,45.65 22.51,43.1 22.77,42.85 22.77,31.22 24.35,29.63 24.35,28.92 24.54,28.73 v1(24.54,28.37)
SUSON: length 177.8
  TOP w0.127: U14.120 27.51,39.09 27.21,38.78 v1(27.01,38.78) ; v1(137.45,24.94) 137,24.5 137,22.6 136.54,22.14 134.96,22.14 134.8,22.3 124.42,22.3 124.24,22.12 124.24,20.03 124.15,19.94 120.4,19.94 119.98,19.52 v1(119.98,19.35) 119.98,12.48 118.41,10.91 117.82,10.91 116.36,9.45 116.36,8.3 115.99,7.93 PR120.2
  IN1 w0.089: v1(27.01,38.78) 27.01,37.18 29.73,34.46 29.73,31.41 31.21,29.93 31.21,28.05 31.79,27.47 33.52,27.47 33.96,27.03 33.96,20.74 35.02,19.68 35.02,18.06 38.19,14.89 46.8,14.89 46.8,14.89 47.87,14.89 49.41,13.35 58.61,13.35 60.99,10.98 74.52,10.98 76.25,12.7 86.08,12.7 90.53,17.15 98.33,17.15 98.93,17.75 111.45,17.75 113.89,20.18 115.99,20.18 118.38,22.58 124.8,22.58 126.35,24.13 129.2,26.99 136.47,26.99 136.94,26.52 136.94,25.45 v1(137.45,24.94)
  BOTTOM w0.127: PR246.2 v1(137.45,24.94) ; v1(27.01,38.78) 27.09,38.7 R550.1
SVID_ALERT#_R: length 3.9
  BOTTOM w0.079: 85.93,72.27 86.23,72.27 U22.G54
  BOTTOM w0.089: R469.2 83.93,72.69 84.35,72.27 85.93,72.27
SVID_CLK#_R: length 6.1
  BOTTOM w0.14: U22.F55 85.85,72.59 84.54,72.59 83.85,73.28 82.83,73.28 82.69,73.41 81.51,73.41 81.36,73.57 80.69,73.57 R462.1
SVID_DAT#_R: length 4.6
  BOTTOM w0.079: U22.G53 86.65,72.22 86.37,71.93 86.19,71.93 86.14,71.98
  BOTTOM w0.089: R471.1 82.59,71.72 82.91,72.04 86.08,72.04 86.14,71.98
SYS_HWPG: length 161.4
  TOP w0.127: v1(165.89,35.29) 164.08,35.29 162.53,36.84 161.11,36.84 159.42,38.53 156.24,38.53 v1(152.81,41.96) ; R300.1 45.63,29.89 v1(45.75,29.77) 46.21,29.77 46.69,30.25 v1(47.02,30.25)
  IN1 w0.089: v1(47.02,30.25) 47.65,29.62 47.65,25.07 47.99,24.73 47.99,21.08 49.01,20.06 83.6,20.06 84.23,19.42 84.23,16.05 84.67,15.61 85.55,15.61 86.22,16.28 86.22,19.28 86.84,19.91 97.66,19.91 98.32,20.57 110.84,20.57 111.35,21.07 112.28,22 112.28,23.72 113.88,25.33 115.82,25.33 117.44,26.95 117.44,29.69 117.94,30.19 131.85,30.19 132.22,30.56 144.95,30.56 145.56,31.17 145.56,31.67 148.09,34.19 149.04,34.19 149.28,34.43 149.28,35.06 150.01,35.79 150.01,37.96 151.82,39.77 151.82,40.97 v1(152.81,41.96)
  BOTTOM w0.127: v1(152.81,41.96) 152.81,42.21 152.24,42.78 PR229.2 ; v1(165.89,35.29) 165.89,35.3 166.21,35.3 167.43,34.08 PR235.2
SYS_SHDN#: length 303.2
  TOP w0.127: R278.2 21.71,39.3 v1(21.72,39.29) 21.76,39.33 22.83,39.33 23.86,38.3 24.3,38.3 25.29,37.31 v1(25.74,37.31) ; v1(152.81,40.94) 153.47,40.94 156.14,38.28 159.31,38.28 161,36.59 162.43,36.59 164.36,34.66 v1(165.89,34.66)
  IN1 w0.089: v1(152.81,40.94) 152.81,40.49 150.24,37.92 150.24,35.76 149.47,34.98 149.47,33.28 146.2,30.01 144.99,30.01 139.99,25.02 139.99,24.68 139.74,24.43 138.77,24.43 136.72,22.38 135.48,22.38 134.63,23.23 125.98,23.23 124.95,22.2 118.61,22.2 116.21,19.8 114.05,19.8 111.61,17.37 99.09,17.37 98.49,16.77 90.68,16.77 86.24,12.32 76.46,12.32 74.74,10.6 60.82,10.6 58.44,12.97 49.25,12.97 47.72,14.51 46.96,14.51 38.03,14.51 34.64,17.9 34.64,19.52 33.58,20.58 33.58,26.82 33.31,27.09 31.63,27.09 30.86,27.86 29.74,27.86 29.54,28.06 29.54,28.57 30.44,29.47 30.44,30.44 29.54,31.34 29.54,34.38 26.61,37.31 v1(25.74,37.31)
  IN2 w0.127: v1(152.81,40.94) 152.31,41.45 152.31,45.39 151.6,46.1 151.6,47.19 152.15,47.75 152.15,48.84 v1(152.81,49.5)
  IN3 w0.127: v1(115.35,89.61) 115.49,89.75 116.39,89.75 116.61,89.97 118.12,89.97 118.34,89.75 118.51,89.75 118.97,89.29 118.97,81.93 119.38,81.52 120.07,81.52 120.9,80.69 121.32,80.69 122.52,79.49 129.61,79.49 130.65,78.45 130.65,74.99 132.63,73.01 136.6,73.01 137.37,72.24 141.54,72.24 142.22,71.56 149.14,71.56 150.36,70.34 153.04,70.34 154.03,71.34 154.03,71.34 154.88,72.19 161.55,72.19 162.53,71.21 162.53,69.56 159.99,67.02 159.99,65.29 160.22,65.06 160.22,63.25 159.76,62.79 159.76,49.01 158.72,47.97 158.72,46.95 158.48,46.71 155.68,46.71 154.94,45.96 154.53,45.96 153.32,44.76 153.32,41.45 v1(152.81,40.94)
  BOTTOM w0.127: v1(152.81,40.94) 153.31,41.44 PR232.2 ; PR226.1 153.31,49 v1(152.81,49.5) ; PR130.1 110.88,87.27 112.9,87.27 113.01,87.38 113.88,88.25 114.95,88.25 115.35,88.65 v1(115.35,89.61) ; PR233.2 165.27,35.17 165.78,34.66 v1(165.89,34.66)
TEMP_MBAT#: length 164.9
  TOP w0.14: U14.73 37.45,29.18 34.34,32.29 31.87,32.29 31.49,31.91 27.57,31.91 v1(27.39,31.72)
  TOP w0.178: PR91.2 v1(149,16.56)
  IN1 w0.089: v1(27.39,31.72) 27.39,31.68 29.06,30.01 29.06,25.23 33.01,21.27 33.01,20.34 34.07,19.29 34.07,17.66 37.8,13.94 47.19,13.94 47.48,13.94 49.03,12.39 58.22,12.39 60.58,10.02 74.97,10.02 76.7,11.75 86.48,11.75 90.92,16.2 97.93,16.2 v1(98.33,15.8) 99.33,16.79 111.05,16.79 111.81,16.03 115.26,16.03 115.66,16.43 119.64,16.43 120.79,15.29 120.79,14.67 123.06,12.41 133.32,12.41 134.83,10.9 135.8,10.9 136.15,10.55 136.38,10.55 136.73,10.9 138.19,10.9 138.95,10.14 138.95,8.96 139.48,8.42 146.19,8.42 148.39,10.62 148.39,15.94 v1(149,16.56)
  BOTTOM w0.127: PR261.2 98.21,15.68 v1(98.33,15.8) 98.33,16.8 PR258.1
THERMTRIP#: length 74.6
  TOP w0.14: v1(45.63,49.72) 45.41,49.5 44.25,49.5 43.82,49.07 37.83,49.07 36.93,48.17 36.93,48.09 36.29,47.46 35.47,47.46 34.77,46.76 33.92,46.76 33.48,46.32 26.28,46.32 25.6,47 R225.2
  IN1 w0.089: v1(45.63,49.72) 45.66,49.69 50.79,49.69 53.66,52.56 53.66,53.37 56.54,56.25 56.54,59.39 62.76,65.61 64.37,65.61 69.74,70.97 69.74,77.81 70.76,78.84 74.91,78.84 v1(75.47,78.28)
  BOTTOM w0.14: v1(75.47,78.28) 75.48,78.28 75.68,78.08 76.26,78.08 76.75,78.57 R438.1 R439.1 78,79.03 77.82,79.21 Q31.3
THRMTRIP#_R: length 27.6
  IN1 w0.089: v1(83,78.36) 83.38,77.98 83.38,77.06 84.55,75.89 85.6,75.89 86.85,74.65 87.79,74.65 89.31,73.12 89.31,72.62 88.96,72.27 85.15,72.27 84.04,71.16 83.8,71.16 v1(83.79,71.14)
  BOTTOM w0.079: U22.J53 86.69,71.32 86.44,71.07 86.11,71.07 86.07,71.11 86.05,71.11 85.56,71.6 85.26,71.6
  BOTTOM w0.089: 85.26,71.6 84.25,71.6 v1(83.79,71.14)
  BOTTOM w0.14: v1(83.79,71.14) 83.25,70.6 82.9,70.6 82.5,70.2 81.91,70.2 R475.1 ; v1(83,78.36) 80.1,78.36 79.67,78.79 78.78,78.79 R439.2 78.65,78.92 78.65,79.69 Q31.2
TOUCH_SCREEN_PWR:
  vias: v1(166.28,80.95) v1(166.4,78.36) v1(166.91,80.95)
TP_EN: length 2.9
  BOTTOM w0.127: CN12.8 76.15,13.34 v1(75.47,14.02) 75.09,14.4 R609.2
TP_INT#_R: length 18.6
  TOP w0.127: v1(75.47,16.31) v1(74.71,16.31) R345.2 76.1,15.17 Q17.1 76.61,15.67 77.22,15.67 77.6,16.05 78.77,16.05 79.03,15.8 79.03,13.14 R352.1 79.53,12.87 79.53,13.13 79.43,13.23 79.43,13.97 79.69,14.22 81.49,14.22 81.87,14.6 Q18.2
  BOTTOM w0.127: v1(75.47,16.31) 75.6,16.18 75.6,15.29 75.99,14.9 C476.1 C477.2 77.9,15.68 R610.1
TP_INT#_R_C: length 2.9
  BOTTOM w0.127: R610.2 78.14,14.75 v1(77.39,14) 77.15,13.77 CN12.7
TPCLK: length 65.5
  TOP w0.14: U14.89 38.37,35.57 39.25,35.57 39.78,35.04 42.68,35.04 42.91,35.28 v1(43.72,35.28) 44,35.28 v1(44.38,34.89)
  IN1 w0.089: v1(80.93,16.31) 79.64,17.59 60.71,17.59 59.17,16.05 51.46,16.05 49.9,17.61 48.29,17.61 45.35,20.56 45.35,21.84 43.96,23.22 43.96,34.48 v1(44.38,34.89)
  BOTTOM w0.14: CN12.2 82.15,13.46 82.2,13.51 C479.2 R612.1 81.07,14.9 80.68,15.29 80.68,16.05 v1(80.93,16.31)
TPD_EN: length 69.9
  TOP w0.127: R274.1 40.16,41.07 41.35,39.89 42.41,39.89 42.94,39.36 45.49,39.36 45.68,39.54 47.02,39.54 47.15,39.42 47.96,39.42 48.46,38.92 48.46,38.83 48.77,38.52 50.32,38.52 v1(50.32,38.53) 50.33,38.52 52.45,38.52 v1(52.62,38.7)
  IN3 w0.127: v1(52.62,38.7) 51.46,38.7 49.6,36.83 49.11,36.83 48.17,35.89 48.17,33.41 48.81,32.76 48.81,29.53 48.28,28.99 48.28,18.24 48.71,17.8 49.33,17.8 50.16,16.98 50.39,16.98 51.33,16.04 54.86,16.04 57.45,13.45 70.58,13.45 v1(73.44,16.31)
  BOTTOM w0.127: R609.1 74.31,14.9 C475.2 73.83,14.9 73.44,15.29 v1(73.44,16.31)
TPD_INT#: length 76.9
  TOP w0.127: v1(74.45,11.48) 73.69,12.24 v1(73.69,13.26) R344.1 R345.1 75.97,13.13 Q17.3
  TOP w0.14: v1(28.23,37.51) 26.17,37.51 25.92,37.76 25.21,37.76 24.49,38.49 24.49,38.94 24.31,39.11 U14.128
  IN1 w0.089: v1(74.45,11.48) 73.86,12.07 60.43,12.07 58.77,13.74 49.82,13.74 42.52,21.04 42.52,26.16 41.45,27.23 34.58,27.23 33.76,28.05 32.02,28.05 31.79,28.28 31.79,30.17 31.26,30.69 31.26,31.77 31.97,32.48 31.97,32.86 31.97,32.86 31.97,33.02 31.61,33.38 31.61,33.39 28.23,36.77 v1(28.23,37.51)
TPDATA: length 65.9
  TOP w0.14: 42.63,36.02 43.97,36.02 v1(44.38,35.61) ; 42.63,36.02 v1(42.62,36.02) ; 42.63,36.02 42.04,35.44 39.95,35.44 39.4,35.98 U14.90
  IN1 w0.089: v1(77.02,16.33) 76.1,17.25 75.84,17.25 75.75,17.16 75.75,16.93 75.66,16.84 75.48,16.84 75.39,16.93 75.39,17.16 75.31,17.25 75.13,17.25 75.04,17.16 75.04,16.93 74.95,16.84 74.77,16.84 74.68,16.93 74.68,17.16 74.59,17.25 60.86,17.25 59.28,15.67 51.59,15.67 51.56,15.71 51.32,15.71 49.76,17.27 48.15,17.27 45,20.42 45,21.7 43.62,23.08 43.62,34.85 v1(44.38,35.61)
  BOTTOM w0.14: v1(77.02,16.33) 78.2,16.33 78.65,15.88 78.65,15.29 79.03,14.9 R611.1 C478.2 81.15,13.92 CN12.3
